* NGSPICE file created from cordic.ext - technology: sky130A

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
X0 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
X0 Y a_251_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_251_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X5 VGND a_251_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 VPWR B_N a_251_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VGND B_N a_251_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_27_297# a_251_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
X0 a_277_47# a_247_21# a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND S0 a_247_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_834_97# a_247_21# a_750_97# VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND A3 a_668_97# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X4 a_1290_413# S1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_834_97# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_750_97# S0 a_757_363# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X7 a_27_47# S0 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0852 ps=0.925 w=0.42 l=0.15
X8 X a_1478_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A1 a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR S0 a_247_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.108 pd=1.36 as=0.108 ps=1.36 w=0.42 l=0.15
X11 X a_1478_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X12 a_193_47# A0 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_750_97# a_1290_413# a_1478_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.269 pd=2.12 as=0.0921 ps=0.99 w=0.42 l=0.15
X14 a_1478_413# S1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0921 pd=0.99 as=0.109 ps=1.36 w=0.42 l=0.15
X15 a_1290_413# S1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X16 a_277_47# a_247_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0852 pd=0.925 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 a_750_97# S0 a_668_97# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X18 a_923_363# a_247_21# a_750_97# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0901 pd=0.995 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 a_757_363# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR A3 a_923_363# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0901 ps=0.995 w=0.42 l=0.15
X21 a_277_47# a_1290_413# a_1478_413# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.151 ps=1.28 w=0.42 l=0.15
X22 a_193_413# A0 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X23 a_193_413# S0 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.108 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X24 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X25 a_1478_413# S1 a_750_97# VNB sky130_fd_pr__nfet_01v8 ad=0.151 pd=1.28 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_381_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A2 a_381_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_465_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_549_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 a_381_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A4 a_381_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_381_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# A1 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
X0 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4b_2 A_N B C D VGND VNB VPB VPWR Y
X0 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_465_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND D a_655_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.117 ps=1.01 w=0.65 l=0.15
X3 a_215_47# B a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_655_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_655_47# C a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.37 pd=1.74 as=0.135 ps=1.27 w=1 l=0.15
X8 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_465_47# C a_655_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=2.8 as=0.135 ps=1.27 w=1 l=0.15
X13 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.18 ps=1.36 w=1 l=0.15
X14 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.37 ps=1.74 w=1 l=0.15
X17 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0882 pd=0.84 as=0.0671 ps=0.75 w=0.42 l=0.15
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0483 pd=0.65 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.072 ps=0.76 w=0.36 l=0.15
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0935 ps=0.965 w=0.36 l=0.15
X6 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X7 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.17 as=0.218 ps=2.2 w=0.84 l=0.15
X8 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0798 ps=0.8 w=0.42 l=0.15
X9 a_1224_47# a_27_47# a_1032_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0945 pd=0.87 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND a_1032_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X12 VPWR a_1182_261# a_1140_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X13 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.149 ps=1.33 w=1 l=0.15
X14 a_1032_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X15 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.125 ps=1.17 w=0.42 l=0.15
X16 a_1296_47# a_1182_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0483 pd=0.65 as=0.0441 ps=0.63 w=0.42 l=0.15
X17 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0798 pd=0.8 as=0.0945 ps=0.87 w=0.42 l=0.15
X19 VPWR SET_B a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X20 a_1032_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0483 ps=0.65 w=0.42 l=0.15
X21 a_1182_261# a_1032_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=2.2 as=0.123 ps=1.17 w=0.84 l=0.15
X22 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1140_413# a_193_47# a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VPWR a_1032_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0882 ps=0.84 w=0.42 l=0.15
X27 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0935 pd=0.965 as=0.166 ps=1.8 w=0.64 l=0.15
X28 a_1182_261# a_1032_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.6 as=0.114 ps=1.01 w=0.54 l=0.15
X29 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X30 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X31 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1.01 as=0.0483 ps=0.65 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.368 pd=1.74 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.231 pd=2.01 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.165 ps=1.82 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.368 ps=1.74 w=1 l=0.15
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
X0 a_600_345# S1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X1 a_788_316# S1 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A3 a_372_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.164 ps=1.33 w=0.64 l=0.15
X3 a_872_316# a_600_345# a_788_316# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0578 ps=0.695 w=0.42 l=0.15
X4 VPWR S0 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 a_1279_413# S0 a_872_316# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=0.995 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND a_788_316# X VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1060_369# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.16 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_872_316# a_27_47# a_1060_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.138 ps=1.16 w=0.42 l=0.15
X9 a_1281_47# a_27_47# a_872_316# VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.072 ps=0.76 w=0.36 l=0.15
X10 a_193_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1064_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0786 pd=0.805 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_872_316# S1 a_788_316# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.6 as=0.0729 ps=0.81 w=0.54 l=0.15
X13 a_872_316# S0 a_1064_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0786 ps=0.805 w=0.36 l=0.15
X14 X a_788_316# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X15 a_788_316# a_600_345# a_288_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0729 pd=0.81 as=0.14 ps=1.6 w=0.54 l=0.15
X16 a_372_413# a_27_47# a_288_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.164 pd=1.33 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VGND A3 a_397_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0819 pd=0.81 as=0.0671 ps=0.75 w=0.42 l=0.15
X18 a_600_345# S1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0819 ps=0.81 w=0.42 l=0.15
X19 a_193_369# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0957 pd=0.965 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 VPWR a_788_316# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.135 ps=1.27 w=1 l=0.15
X21 a_288_47# S0 a_193_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0957 ps=0.965 w=0.42 l=0.15
X22 a_397_47# S0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X23 VGND A0 a_1281_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.066 ps=0.745 w=0.42 l=0.15
X24 a_288_47# a_27_47# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.066 ps=0.745 w=0.36 l=0.15
X25 X a_788_316# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.154 ps=1.34 w=1 l=0.15
X26 VGND S0 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 VPWR A0 a_1279_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.154 pd=1.34 as=0.105 ps=0.995 w=0.64 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.219 pd=1.33 as=0.101 ps=0.96 w=0.65 l=0.15
X1 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.219 ps=1.33 w=0.65 l=0.15
X2 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.105 ps=1.21 w=1 l=0.15
X3 a_333_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.305 ps=1.61 w=1 l=0.15
X4 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VPWR A1 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X7 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X8 a_461_297# A2 a_333_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X9 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VGND a_415_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_415_21# A2_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_717_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_193_47# a_415_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_415_21# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X11 a_415_21# A2_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_193_47# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# B2 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_193_47# a_415_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_27_297# a_415_21# a_193_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 VPWR A1_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_717_297# A2_N a_415_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
X2 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.157 ps=1.32 w=1 l=0.15
X4 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X5 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X9 a_381_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_138_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_138_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.185 ps=1.37 w=1 l=0.15
X3 a_138_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A3 a_222_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.135 ps=1.27 w=1 l=0.15
X5 Y C1 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 a_222_297# A2 a_138_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X8 a_458_47# B1 a_138_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.198 ps=1.26 w=0.65 l=0.15
X9 a_138_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 a_109_47# A2_N a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 a_397_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2_N a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.283 pd=1.52 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_397_297# a_109_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.34 ps=2.68 w=1 l=0.15
X5 a_481_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.283 ps=1.52 w=0.65 l=0.15
X7 VGND B1 a_481_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_109_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_484_297# B2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B2 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_96_21# B1 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X8 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_484_297# B1 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_484_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A2 a_918_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_96_21# B2 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 a_96_21# B1 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_484_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_96_21# A1 a_918_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A2 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X18 a_566_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X19 a_918_47# A1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_566_47# B1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_918_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X22 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.159 ps=1.14 w=0.65 l=0.15
X3 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.135 ps=1.27 w=1 l=0.15
X4 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X16 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.159 pd=1.14 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X35 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X39 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt cordic VGND VPWR clk cos[0] cos[10] cos[11] cos[12] cos[13] cos[14] cos[15]
+ cos[1] cos[2] cos[3] cos[4] cos[5] cos[6] cos[7] cos[8] cos[9] in_valid out_valid
+ ready rstb sin[0] sin[10] sin[11] sin[12] sin[13] sin[14] sin[15] sin[1] sin[2]
+ sin[3] sin[4] sin[5] sin[6] sin[7] sin[8] sin[9] theta[0] theta[10] theta[11] theta[12]
+ theta[13] theta[14] theta[15] theta[1] theta[2] theta[3] theta[4] theta[5] theta[6]
+ theta[7] theta[8] theta[9]
X_3155_ _0338_ _0340_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__a21oi_1
X_4619__33 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__inv_2
X_3086_ _0271_ _0272_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3988_ net74 net80 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__xor2_4
X_2939_ net152 _2240_ _1839_ _2280_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__o31a_1
XFILLER_0_48_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3911_ _1009_ _1060_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__or2_1
X_3842_ _1011_ _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3773_ _0423_ _0321_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2724_ _2072_ _2078_ _2082_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nor3_1
X_2655_ _2024_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4325_ _1470_ _1476_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__xnor2_1
X_2586_ _1959_ _1975_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__or2_1
Xfanout138 vec\[0\]\[5\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_2
Xfanout127 net128 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_2
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_4
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_8
X_4256_ _1397_ _1415_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__xnor2_2
Xfanout149 net150 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_2
X_4187_ _1315_ _1326_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__xor2_2
X_3207_ net120 net124 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__xor2_4
XFILLER_0_69_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3138_ net112 net118 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nand2_2
X_3069_ _1968_ _1969_ _2240_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2440_ _1798_ _1827_ _1831_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2371_ slte0.opB\[7\] slte0.opA\[7\] VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__or2b_1
XFILLER_0_75_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4110_ _1278_ _1280_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4041_ _1207_ _1210_ _1211_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__or3_1
XFILLER_0_74_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3825_ net69 VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__inv_2
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3756_ net102 _0942_ _0428_ _0260_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__o31a_1
X_2707_ net159 _2063_ _2065_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3687_ net124 net129 _0434_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2638_ net168 _1853_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__nand2_8
X_2569_ _1795_ _1805_ net55 VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_10_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4308_ _1468_ _1478_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__xnor2_2
X_4239_ _1403_ _1408_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3610_ _0792_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__xor2_1
X_3541_ _0726_ _0711_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3472_ net141 _0658_ net147 VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__o21ai_1
X_2423_ _1811_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__nor2_1
X_2354_ slte0.opB\[13\] VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__inv_2
X_4024_ net345 _1192_ _1193_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3808_ _0979_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__inv_2
X_4788_ net279 _0201_ net175 VGND VGND VPWR VPWR vec\[1\]\[4\] sky130_fd_sc_hd__dfrtp_1
X_3739_ _0577_ _0574_ _0576_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__or3_1
XFILLER_0_38_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2972_ slte0.opA\[2\] _2312_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4711_ net202 _0124_ net174 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_44_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4573_ _1335_ _1422_ _1730_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__or3_1
X_3524_ _0660_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__xnor2_1
X_3455_ _0600_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nor2_1
X_2406_ _1739_ _1796_ _1797_ net104 VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__a22o_1
X_3386_ _0511_ _0515_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4007_ net76 _1174_ _1176_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__o22ai_2
X_4664__78 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__inv_2
XFILLER_0_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold41 net22 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 net45 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_20_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3240_ _0259_ _0268_ _0426_ net103 VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__a22o_1
X_3171_ _0303_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2955_ _2295_ _2296_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__nor2_1
X_2886_ _2132_ _2134_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__nand2_1
X_4556_ _1667_ _1718_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3507_ net133 net139 _0692_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4487_ _1656_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__and2b_1
X_3438_ _0326_ _0623_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__a21oi_1
X_3369_ net124 net131 _0549_ _0548_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput31 net31 VGND VGND VPWR VPWR cos[6] sky130_fd_sc_hd__clkbuf_4
Xoutput20 net20 VGND VGND VPWR VPWR cos[10] sky130_fd_sc_hd__clkbuf_4
Xoutput42 net42 VGND VGND VPWR VPWR sin[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2740_ _2091_ _2094_ _2098_ _1792_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__a31o_1
X_2671_ _2032_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_4410_ _1564_ _1568_ _1344_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4341_ _1495_ _1511_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__xor2_2
X_4272_ _1428_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__and2_1
X_3223_ _0408_ _0407_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and2b_1
X_3154_ _0264_ _0335_ _0337_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__nor3_1
X_3085_ _0259_ net108 _0267_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__mux2_1
X_4634__48 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__inv_2
XFILLER_0_9_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3987_ net294 net345 VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2938_ net152 _2264_ _2260_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2869_ net167 net132 _1981_ _2217_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4539_ _1704_ _1705_ _1154_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4591__5 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
X_3910_ _1078_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3841_ _1006_ _1010_ _1007_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__a21oi_1
X_3772_ net332 _0947_ _0954_ _0955_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2723_ _1841_ _2081_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__and2_1
X_2654_ slte0.opB\[10\] net4 _2018_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__mux2_1
X_2585_ net169 _1974_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__nand2_4
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4324_ _1467_ net293 VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__xnor2_2
Xfanout117 vec\[0\]\[12\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_2
Xfanout128 vec\[0\]\[8\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_4
Xfanout106 net107 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_4
X_4255_ _1382_ _1421_ _1424_ _1425_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__a211o_1
Xfanout139 net140 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_4
X_3206_ _0388_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__nor2_1
X_4186_ _1355_ _1356_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__and2_1
X_3137_ net106 net111 _0265_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__and3_2
X_3068_ _0253_ _0256_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2370_ slte0.opB\[11\] _1745_ _1754_ _1761_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__o211ai_4
X_4040_ _1023_ _1206_ _1204_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4604__18 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__inv_2
XFILLER_0_19_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3824_ _0991_ _0993_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3755_ net106 VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2706_ _1739_ _2064_ net341 VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__a21o_1
X_3686_ _0440_ _0755_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2637_ _2012_ _1989_ _2013_ net97 _2006_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a32o_1
XFILLER_0_10_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2568_ net55 _1795_ _1804_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__and3_1
X_4307_ _1470_ _1476_ _1477_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__a21oi_2
X_2499_ net69 _1890_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__nand2_1
X_4238_ _1403_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4169_ _1163_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3540_ _0711_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3471_ net136 net142 VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__xor2_4
X_2422_ _1741_ _1813_ _1807_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__mux2_1
X_2353_ slte0.opA\[11\] VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__inv_2
X_4023_ net71 net76 VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__nand2_4
XFILLER_0_47_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3807_ _0258_ _0980_ _0981_ _0975_ net300 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a32o_1
X_4787_ net278 _0200_ net175 VGND VGND VPWR VPWR vec\[1\]\[3\] sky130_fd_sc_hd__dfrtp_1
X_3738_ _0537_ _0579_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3669_ _0807_ _0809_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2971_ _1775_ _2312_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__xnor2_1
X_4710_ net201 _0123_ net174 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_21_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4572_ _1335_ _1730_ _1422_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_52_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3523_ _0661_ _0671_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__xnor2_1
X_3454_ _0614_ _0639_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21boi_1
X_2405_ net163 net158 VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__nor2b_2
X_3385_ _0565_ _0570_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_79_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4006_ net345 net81 VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__nand2_4
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold31 net33 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 net50 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net36 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3170_ net112 net106 net103 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__and3b_1
XFILLER_0_16_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2954_ slte0.opA\[5\] _2294_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2885_ net170 _2227_ _2228_ _2229_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4555_ _1654_ _1655_ _1672_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__a21o_1
X_3506_ net137 _0691_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4486_ _1614_ _1625_ _1623_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a21o_1
X_3437_ net112 net119 _0301_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__and3_1
X_3368_ net134 _0554_ net141 VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__o21ai_2
X_3299_ _0447_ _0448_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput32 net32 VGND VGND VPWR VPWR cos[7] sky130_fd_sc_hd__clkbuf_4
Xoutput21 net21 VGND VGND VPWR VPWR cos[11] sky130_fd_sc_hd__clkbuf_4
Xoutput43 net43 VGND VGND VPWR VPWR sin[15] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2670_ slte0.opB\[2\] net11 _2017_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4340_ _1496_ _1506_ _1509_ _1510_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__o22a_1
X_4271_ net83 net85 VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__or2_1
X_3222_ _0407_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__and2b_1
X_3153_ _0334_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3084_ net115 _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3986_ _1049_ _1076_ _1081_ _1155_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__o221a_1
XFILLER_0_9_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2937_ slte0.opA\[9\] _2278_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2868_ _2146_ _2151_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2799_ _2146_ _2151_ _2156_ _2157_ _2155_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__a311o_1
X_4538_ _1677_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__inv_2
XFILLER_0_7_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4469_ _1268_ _1289_ _1639_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4692__106 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__inv_2
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3840_ _1006_ _1007_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__and3_1
X_3771_ _2014_ _0937_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2722_ _2051_ _2040_ _2079_ _2080_ net156 _1822_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__mux4_1
X_2653_ _2023_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2584_ _1842_ net341 _1804_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__or3b_4
X_4323_ net98 _1493_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__and2_2
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout129 vec\[0\]\[7\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_4
Xfanout107 vec\[0\]\[15\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_2
Xfanout118 net120 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_4
X_4254_ _1381_ _1378_ _1380_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__nor3_1
XFILLER_0_38_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4185_ net100 _1347_ _1354_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__or3_1
X_3205_ _0389_ _0391_ net123 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
X_3136_ _2170_ _0313_ _0319_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__o21bai_1
X_3067_ net167 net166 net158 VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3969_ _1126_ _1122_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__or2b_1
XFILLER_0_45_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3823_ net53 net56 VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3754_ net102 _0428_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2705_ net91 net89 net165 VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__mux2_1
X_3685_ _0695_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__xnor2_1
X_2636_ _2011_ _1932_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__nand2_1
X_2567_ _1883_ _1956_ _1958_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_49_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4306_ _1471_ _1475_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__and2b_1
X_2498_ _1815_ _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__xor2_1
X_4237_ _1404_ _1406_ _1407_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__a21oi_4
X_4168_ net78 net79 VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__nand2_1
X_4099_ _1175_ _1177_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__xnor2_4
X_3119_ net117 _0304_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_80_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4685__99 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__inv_2
XFILLER_0_56_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3470_ _0655_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__nor2_1
X_2421_ _1812_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__inv_2
X_2352_ net152 _1741_ net341 VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__or3_1
X_4022_ _1128_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__xor2_2
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3806_ _0686_ _0979_ _0644_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__o21ai_1
X_4786_ net277 _0199_ net175 VGND VGND VPWR VPWR vec\[1\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3737_ _0644_ _0688_ _0734_ _0922_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a41o_2
XFILLER_0_15_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3668_ _0807_ _0809_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__nand2_1
X_2619_ _1915_ _1944_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__nand2_1
X_3599_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_2_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2970_ _2255_ _2311_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4571_ _1729_ _1724_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3522_ _0707_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2_1
X_3453_ _0616_ _0638_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand2_1
X_2404_ net110 net107 net163 VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
X_3384_ _0538_ _0564_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__nor2_1
X_4005_ net342 _1174_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4769_ net260 _0182_ net171 VGND VGND VPWR VPWR slte0.opB\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold21 net29 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 net26 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 net31 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 slte0.opA\[6\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
X_4655__69 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__inv_2
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2953_ slte0.opA\[5\] _2294_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__and2_1
X_2884_ net169 net146 _1981_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4554_ _1716_ _1668_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3505_ _0554_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__or2b_1
X_4485_ _1142_ _1143_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__xnor2_1
X_3436_ _0601_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__and2_1
X_3367_ net129 net136 VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__xor2_4
X_3298_ _0484_ _0455_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput33 net33 VGND VGND VPWR VPWR cos[8] sky130_fd_sc_hd__clkbuf_4
Xoutput22 net22 VGND VGND VPWR VPWR cos[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput44 net44 VGND VGND VPWR VPWR sin[1] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4270_ _1404_ _1406_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__xor2_4
X_3221_ _0361_ _0370_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__xor2_1
X_3152_ net125 _0329_ _0333_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__or3_1
X_3083_ _0266_ _0269_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3985_ _1079_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2936_ _1793_ _2259_ _2277_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2867_ _1985_ _2215_ _2216_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2798_ _2154_ _2149_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__nor2_1
X_4537_ _1654_ _1670_ _1673_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4468_ _1288_ _1285_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__and2b_1
X_3419_ _0554_ _0605_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__xnor2_2
X_4399_ _1344_ _1564_ _1568_ _1569_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__a31oi_2
X_4625__39 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__inv_2
XFILLER_0_48_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3770_ _0936_ _0424_ _0932_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__or3_1
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2721_ net83 net79 net78 net74 net165 net160 VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__mux4_1
XFILLER_0_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2652_ slte0.opB\[11\] net5 _2018_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__mux2_1
X_2583_ _1970_ _1972_ _1973_ net57 _1971_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a32o_1
XFILLER_0_10_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4322_ _1461_ _1491_ _1492_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__nor3_1
X_4253_ _1422_ _1423_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nand2_2
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_4
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_2
X_3204_ _0362_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__xnor2_4
X_4184_ _1347_ _1354_ net100 VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__o21ai_1
X_3135_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__inv_2
X_3066_ _1808_ _0253_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3968_ _1119_ _1138_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__or2b_1
XFILLER_0_45_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2919_ _1888_ _2260_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__nor2_1
X_3899_ _1061_ _1062_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3822_ net53 _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__or2_1
X_3753_ _0260_ _0264_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__or3_1
X_2704_ net85 net83 net165 VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3684_ _0869_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__and2b_1
X_2635_ _2011_ _1932_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4305_ _1471_ _1475_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__xnor2_2
X_2566_ _1877_ _1957_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__or2_1
X_2497_ _1888_ _1869_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__and2_1
X_4236_ net71 net77 _1128_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__and3_1
X_4167_ _1312_ _1329_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3118_ net115 _0286_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nor2_1
X_4098_ net294 _1208_ _1209_ _1124_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_77_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3049_ _2305_ _2315_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__or2_1
XFILLER_0_81_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout90 vec\[1\]\[4\] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_6
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2420_ net118 net115 net113 net110 net163 net159 VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__mux4_1
X_2351_ _1742_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__buf_1
X_4021_ net65 net67 VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__nand2_2
X_3805_ _0644_ _0686_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__or3_1
X_4785_ net276 _0198_ net175 VGND VGND VPWR VPWR vec\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
X_3736_ _0643_ _0686_ _0642_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3667_ _0847_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__xnor2_1
X_2618_ _1978_ net79 _1985_ _2000_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a22o_1
X_3598_ net145 net151 VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__and2_1
X_2549_ _1928_ _1940_ _1926_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__a21o_1
X_4219_ net99 _1389_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4570_ _1423_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__inv_2
XFILLER_0_37_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3521_ net151 _0699_ _0706_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__or3_1
X_3452_ _0616_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__xor2_1
X_3383_ _0568_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__and2_1
X_2403_ net152 net341 VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__nor2_2
XFILLER_0_46_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4004_ net70 net77 VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__xor2_4
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4768_ net259 _0181_ net171 VGND VGND VPWR VPWR slte0.opB\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_70_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4699_ net190 _0112_ net176 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
X_3719_ _0893_ _0895_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold11 net34 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 net39 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net40 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 slte0.opA\[5\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_78_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2952_ _2273_ _2293_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2883_ _2136_ _2139_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__or2_1
X_4553_ _1662_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__inv_2
XFILLER_0_25_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4484_ _1645_ _1650_ _1644_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3504_ net127 net130 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nand2_1
X_3435_ net121 net125 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3366_ _0539_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3297_ _0452_ _0453_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput34 net34 VGND VGND VPWR VPWR cos[9] sky130_fd_sc_hd__clkbuf_4
Xoutput23 net23 VGND VGND VPWR VPWR cos[13] sky130_fd_sc_hd__clkbuf_4
Xoutput45 net45 VGND VGND VPWR VPWR sin[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3220_ _0404_ _0405_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a21oi_1
X_3151_ _0336_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__xnor2_2
X_3082_ net109 _0267_ _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a21bo_1
X_3984_ _1154_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2935_ _1803_ _1797_ _2270_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__a21oi_1
X_2866_ net168 net129 VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__nor2_1
X_2797_ _2154_ _2155_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_15_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4536_ net324 _0947_ _1703_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__a21bo_1
X_4467_ _1633_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4398_ net89 net95 _1305_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__and3_1
X_3418_ net134 net139 VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nand2_2
X_3349_ _0474_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2720_ net95 net91 net89 net85 net165 net161 VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__mux4_1
X_2651_ _2022_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
X_2582_ _1877_ _1959_ _1880_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__or3_1
X_4321_ _1393_ _1490_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4252_ _1296_ _1334_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__xor2_2
Xfanout109 net110 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_4
X_3203_ net120 net123 VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__nand2_2
X_4183_ _1348_ _1353_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3134_ _0295_ _0296_ _0317_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__o211a_1
X_3065_ _1839_ _0253_ _0254_ net341 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3967_ _1130_ _1136_ _1137_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a21bo_1
X_2918_ net341 _2241_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__or2_2
XFILLER_0_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3898_ _1067_ _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2849_ _2198_ _2203_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4519_ _1019_ _1688_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3821_ net58 net62 VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3752_ _0281_ _0937_ _0938_ _0280_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o2bb2a_1
X_2703_ net155 _2049_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__nand2_1
X_3683_ _0658_ _0848_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__or2b_1
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2634_ _1933_ _1931_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__or2_1
X_2565_ net60 _1876_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4304_ _1196_ _1473_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_49_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2496_ _1887_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__clkbuf_4
X_4235_ _1384_ _1405_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__and2_4
X_4166_ _1295_ _1335_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3117_ _0303_ _0286_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_27_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4097_ _1266_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__and2_1
X_3048_ _2305_ _2315_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout80 net81 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_4
Xfanout91 net93 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_54_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2350_ net154 net157 VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_63_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4020_ net81 _1179_ net87 VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4784_ net275 _0197_ net175 VGND VGND VPWR VPWR vec\[1\]\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_55_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3804_ _0688_ _0734_ _0922_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3735_ _0735_ _0773_ _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_70_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3666_ _0851_ _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__xnor2_1
X_2617_ _1997_ _1999_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__xor2_1
X_3597_ _0778_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_81_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2548_ _1934_ _1938_ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__o21bai_1
X_4218_ _1343_ _1350_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__and2_1
X_2479_ _1801_ _1810_ _1870_ _1794_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__a31o_1
X_4149_ _1298_ _1319_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__and2_4
XFILLER_0_65_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3520_ _0699_ _0706_ net151 VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_64_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3451_ _0634_ _0636_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21bo_1
X_3382_ vec\[0\]\[3\] _0566_ _0567_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__or3_1
X_2402_ _1793_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__clkbuf_4
X_4003_ net68 net294 VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__nand2_2
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4767_ net258 _0180_ net178 VGND VGND VPWR VPWR vec\[0\]\[16\] sky130_fd_sc_hd__dfrtp_1
X_4698_ net189 _0111_ net176 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_1
X_3718_ _0749_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__xnor2_1
X_3649_ _0822_ _0828_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold23 net43 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 net42 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
X_4688__102 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__inv_2
Xhold34 net24 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 slte0.opA\[8\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4594__8 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__inv_2
XFILLER_0_16_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2951_ _2097_ _2253_ _2257_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2882_ _2136_ _2139_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4552_ _0950_ _1711_ _1715_ _0975_ net304 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a32o_1
X_4483_ _1337_ _1426_ _1600_ _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__a31o_4
X_3503_ _0675_ _0679_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3434_ _0304_ _0543_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__xor2_2
X_3365_ _0546_ _0550_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__a21boi_2
X_3296_ _0481_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_73_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4660__74 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__inv_2
XFILLER_0_75_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput24 net24 VGND VGND VPWR VPWR cos[14] sky130_fd_sc_hd__clkbuf_4
Xoutput46 net46 VGND VGND VPWR VPWR sin[3] sky130_fd_sc_hd__clkbuf_4
Xoutput35 net35 VGND VGND VPWR VPWR out_valid sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ net103 _0309_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__xnor2_2
X_3081_ net105 net108 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3983_ _1117_ _1152_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__a21oi_1
X_2934_ slte0.opA\[10\] _2275_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__nand2_2
X_2865_ _2214_ _2156_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4535_ _1691_ _1157_ _1678_ _1700_ _2014_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__a311o_1
X_2796_ net129 _2153_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__and2_1
X_4466_ _1631_ _1632_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__or2_1
X_4397_ net97 net100 VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__or2_1
X_3417_ net128 net133 _0602_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a31o_1
X_3348_ _0533_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3279_ net126 net133 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__nand2_2
XFILLER_0_48_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2650_ slte0.opB\[12\] net6 _2018_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2581_ _1877_ _1959_ _1880_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__o21ai_1
X_4320_ net98 _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__nor2_1
X_4251_ _1294_ _1264_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3202_ _0362_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__inv_2
X_4182_ net99 _1352_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__and2_1
X_3133_ _2170_ _0313_ _0319_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__or3b_2
X_3064_ _1842_ _0254_ _0255_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3966_ _1088_ _1133_ _1134_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__or3_1
X_4630__44 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__inv_2
XFILLER_0_70_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2917_ _2256_ _2258_ _1792_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__a21oi_4
X_3897_ _1061_ _1062_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2848_ _2118_ _2180_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2779_ _2082_ _2137_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__xor2_1
X_4518_ _1019_ _1688_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__or2_1
X_4449_ _1617_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__and2b_1
XFILLER_0_63_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3820_ net53 _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3751_ _0934_ _0277_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__and2b_1
XFILLER_0_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2702_ net79 net77 net75 net295 net163 net159 VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__mux4_1
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3682_ net143 _0848_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2633_ _2009_ _1989_ _2010_ net95 _2006_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a32o_1
X_2564_ _1886_ _1954_ _1955_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4303_ net78 net84 _1159_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__and3_1
X_2495_ _1791_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4234_ net80 net82 VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__or2_1
X_4165_ _1294_ _1264_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__or2b_1
X_3116_ net109 net116 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__nand2_2
X_4096_ net344 _1265_ _1200_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__or3_1
X_3047_ _0243_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3949_ net64 _1025_ _0990_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout70 net71 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_12
Xfanout81 vec\[1\]\[7\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_6
Xfanout92 net93 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3803_ net312 _0947_ _0978_ net340 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4600__14 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__inv_2
XFILLER_0_51_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4783_ net274 _0196_ net180 VGND VGND VPWR VPWR slte0.opB\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3734_ _0771_ _0772_ _0918_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__nand4b_2
XFILLER_0_15_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3665_ _0467_ _0806_ _0468_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a21oi_1
X_2616_ _1998_ _1909_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3596_ _0606_ _0781_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__a21oi_2
X_2547_ _1935_ _1937_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2478_ _1815_ _1869_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__nor2_2
X_4217_ _1349_ _1351_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__or2_1
X_4148_ net73 net76 VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__or2_1
X_4079_ _1158_ _1249_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__and2_4
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4666__80 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__inv_2
XFILLER_0_72_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3450_ _0633_ _0618_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__or2b_1
X_3381_ _0566_ _0567_ vec\[0\]\[3\] VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__o21ai_2
X_2401_ _1792_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__clkbuf_4
X_4002_ _1935_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4766_ net257 _0179_ net180 VGND VGND VPWR VPWR vec\[0\]\[15\] sky130_fd_sc_hd__dfstp_1
X_3717_ _0750_ _0760_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__xnor2_1
X_4697_ net188 _0110_ net175 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3648_ _0822_ _0828_ _0832_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__a211o_1
X_3579_ _0748_ _0745_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and2b_1
Xhold13 net51 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net23 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 net47 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 slte0.opA\[10\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2950_ _2290_ _2291_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2881_ net169 _2224_ _2225_ _2226_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4551_ _1676_ _1704_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__or2_1
X_4482_ _1646_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3502_ _0677_ _0683_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__xor2_1
X_3433_ _0466_ _0602_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__xnor2_2
X_3364_ _0545_ _0540_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__or2b_1
X_3295_ _0465_ _0469_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4749_ net240 _0162_ net180 VGND VGND VPWR VPWR slte0.opA\[15\] sky130_fd_sc_hd__dfrtp_2
Xoutput25 net25 VGND VGND VPWR VPWR cos[15] sky130_fd_sc_hd__clkbuf_4
Xoutput47 net47 VGND VGND VPWR VPWR sin[4] sky130_fd_sc_hd__clkbuf_4
Xoutput36 net36 VGND VGND VPWR VPWR ready sky130_fd_sc_hd__clkbuf_4
X_4636__50 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__inv_2
XFILLER_0_81_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3080_ net102 net105 VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__xor2_4
XFILLER_0_9_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3982_ _1116_ _1111_ _1114_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__nor3_1
X_2933_ _2273_ _2274_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2864_ _2146_ _2151_ _2149_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_4_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2795_ net129 _2153_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__nor2_1
X_4534_ _0950_ _1701_ _1702_ _0975_ net309 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__a32o_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4465_ _1603_ _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4396_ _1302_ _1546_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__xnor2_2
X_3416_ vec\[0\]\[7\] _0601_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__nor2_1
X_3347_ _0444_ _0471_ _0477_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__o21ai_1
X_3278_ net127 _0458_ _0464_ net133 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ _1965_ _1966_ _1970_ _1971_ net55 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__a32o_1
XFILLER_0_10_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4250_ _1418_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3201_ net117 _0259_ _0325_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__o22a_1
X_4181_ _1349_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__nand2_1
X_3132_ _0317_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__and2_1
X_3063_ _1842_ _0254_ _2014_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_54_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3965_ _1133_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__xnor2_1
X_3896_ _1065_ _1066_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__and2_1
X_2916_ _1808_ _2096_ _2244_ _2257_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__o211a_2
X_2847_ _2200_ _2201_ _2202_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2778_ _1762_ _1790_ _2078_ _2130_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4517_ _1679_ _1681_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__xnor2_1
X_4448_ _1278_ _1280_ _1618_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__a21oi_1
X_4379_ _1545_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__xor2_1
X_4606__20 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__inv_2
XFILLER_0_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3750_ _0424_ _0932_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__o21a_1
XFILLER_0_40_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2701_ net153 _2059_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__nor2_1
X_3681_ _0866_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2632_ _1934_ _1938_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2563_ net63 _1882_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__or2_1
X_4302_ _1458_ _1472_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__and2_1
X_4233_ _1128_ _1194_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__xnor2_4
X_2494_ net66 _1885_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__and2_4
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4164_ _1296_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__and2_1
X_4095_ _1265_ _1200_ net344 VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__o21ai_2
X_3115_ net112 _0301_ net118 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__o21ai_2
X_3046_ _1975_ _0241_ _0242_ _1765_ net168 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__o32a_1
XFILLER_0_77_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3948_ _1099_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3879_ _1040_ _1041_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout71 net72 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_6
Xfanout82 net84 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__buf_4
Xfanout60 vec\[1\]\[14\] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_2
Xfanout93 vec\[1\]\[3\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4597__11 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__inv_2
X_3802_ _0924_ _0927_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4782_ net273 _0195_ net178 VGND VGND VPWR VPWR slte0.opB\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3733_ _0914_ _0916_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3664_ _0462_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2615_ _1945_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3595_ net135 net139 _0554_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__and3_1
X_2546_ _1935_ _1937_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__xnor2_1
X_2477_ _1818_ _1821_ _1826_ _1868_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__or4_1
X_4216_ net86 net93 _1385_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4147_ _1056_ _1250_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__xnor2_2
X_4078_ net70 net73 VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__or2_1
X_3029_ _2322_ _2283_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__and2b_1
XFILLER_0_38_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4681__95 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__inv_2
XFILLER_0_56_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2400_ _1791_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__buf_4
X_3380_ _0555_ _0561_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__and2b_1
X_4001_ _1162_ _1167_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4765_ net256 _0178_ net180 VGND VGND VPWR VPWR vec\[0\]\[14\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_7_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3716_ _0891_ _0888_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__and2b_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4696_ net187 _0109_ net175 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfrtp_1
X_3647_ _0696_ _0824_ _0825_ _0833_ _0742_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__a311o_1
X_3578_ _0763_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__or2b_1
X_2529_ _1844_ _1920_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__xnor2_1
Xhold14 net46 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net30 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net52 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 slte0.opA\[15\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_78_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2880_ net169 net144 _1981_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4550_ _1713_ _1714_ net327 _0947_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_25_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3501_ _0686_ _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nor2_1
X_4481_ _1650_ _1651_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__and2_1
X_3432_ _0546_ _0550_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__xnor2_2
X_3363_ _0461_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3294_ _0480_ _0457_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_69_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4748_ net239 _0161_ net180 VGND VGND VPWR VPWR slte0.opA\[14\] sky130_fd_sc_hd__dfrtp_2
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput26 net26 VGND VGND VPWR VPWR cos[1] sky130_fd_sc_hd__clkbuf_4
Xoutput48 net48 VGND VGND VPWR VPWR sin[5] sky130_fd_sc_hd__clkbuf_4
Xoutput37 net37 VGND VGND VPWR VPWR sin[0] sky130_fd_sc_hd__clkbuf_4
X_4651__65 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__inv_2
XFILLER_0_26_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3981_ _1146_ _1150_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__o21ai_2
X_2932_ _1839_ _2241_ _2252_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2863_ _1985_ _2213_ net167 net126 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__o2bb2a_1
X_2794_ _2094_ _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4533_ _1686_ _1699_ _1700_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__or3_1
XFILLER_0_13_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4464_ _1626_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4395_ net100 VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__inv_2
X_3415_ net131 _0458_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__mux2_1
X_3346_ _0527_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__xnor2_1
X_3277_ _0459_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4180_ _1343_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__nand2_1
X_3200_ net106 net109 _0301_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__a21oi_1
X_3131_ _0298_ _0316_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3062_ _2242_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3964_ _1088_ _1134_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3895_ net75 _1063_ _1064_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__or3_1
X_2915_ net156 _2243_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2846_ net167 net111 VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2777_ _2132_ _2134_ _2135_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4516_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__inv_2
X_4447_ _1008_ _1279_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__nor2_1
X_4378_ _1302_ _1547_ _1548_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__a21o_1
X_3329_ _0483_ _0510_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__and2b_1
X_4621__35 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__inv_2
XFILLER_0_63_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2700_ _1828_ _2054_ _2058_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3680_ _0788_ _0865_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2631_ _1934_ _1938_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__or2_1
X_2562_ _1892_ _1949_ _1950_ _1953_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4301_ net86 net88 VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4232_ _1125_ _1366_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__xor2_4
X_2493_ _1810_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__xnor2_1
X_4163_ _1310_ _1332_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4094_ _1195_ _1198_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3114_ net110 net115 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__xor2_4
X_3045_ _2302_ _2317_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__and2_1
XFILLER_0_81_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3947_ _1097_ _1098_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3878_ _1020_ _1021_ _1048_ _1045_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__o211a_1
XFILLER_0_26_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2829_ _2186_ _2187_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout61 net62 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_6
Xfanout72 vec\[1\]\[10\] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_6
Xfanout83 net84 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_4
XFILLER_0_64_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout94 net95 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3801_ net316 _0947_ _0977_ net340 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__a22o_1
X_4781_ net272 _0194_ net180 VGND VGND VPWR VPWR slte0.opB\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3732_ _0770_ _0765_ _0769_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3663_ _0848_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2614_ _1913_ _1996_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__nand2_1
X_3594_ _0779_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__and2_1
X_2545_ _1852_ _1936_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__xnor2_1
X_2476_ _1863_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__nand2_1
X_4215_ net90 _1384_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4146_ _1180_ _1299_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_50_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4077_ _1028_ _1231_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__xnor2_2
X_3028_ _1971_ net339 _1985_ _0229_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4000_ _1169_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__and2b_1
X_4657__71 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__inv_2
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4764_ net255 _0177_ net184 VGND VGND VPWR VPWR vec\[0\]\[13\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_43_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3715_ _0863_ _0884_ _0885_ _0887_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a32o_1
X_4695_ net186 _0108_ net175 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfstp_1
XFILLER_0_30_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3646_ _0702_ _0741_ net151 VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3577_ _0712_ _0724_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__xor2_1
X_2528_ _1791_ _1862_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__nor2_1
Xhold15 net38 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net44 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 net37 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ _1816_ _1798_ _1850_ _1829_ net157 _1822_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__mux4_1
Xhold48 slte0.opA\[9\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
X_4129_ net82 _1298_ _1299_ _1180_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3500_ _0685_ _0682_ _0684_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__nor3_1
XFILLER_0_4_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4480_ _1647_ _1648_ _1649_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__or3_1
X_3431_ _0617_ _0562_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3362_ _0547_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3293_ _0451_ _0456_ _0446_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_73_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4747_ net238 _0160_ net180 VGND VGND VPWR VPWR slte0.opA\[13\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_31_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3629_ _2133_ _0779_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nand2_1
Xoutput49 net49 VGND VGND VPWR VPWR sin[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput38 net38 VGND VGND VPWR VPWR sin[10] sky130_fd_sc_hd__clkbuf_4
Xoutput27 net27 VGND VGND VPWR VPWR cos[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4627__41 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__inv_2
XFILLER_0_43_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3980_ _1104_ _1113_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__xor2_1
X_2931_ _1887_ _2263_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_2862_ _2158_ _2163_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__xnor2_1
X_2793_ _1792_ _2091_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__or2_1
X_4532_ _1699_ _1700_ _1686_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4463_ _1628_ _1629_ _1633_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3414_ net121 net125 VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4394_ _1544_ _1550_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3345_ _0530_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3276_ _0460_ _0462_ net131 VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3130_ _0298_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nand2_1
X_3061_ net167 net158 net166 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3963_ net53 _1028_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3894_ _1063_ _1064_ net75 VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__o21ai_1
X_2914_ _2250_ _2255_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__and2_2
XFILLER_0_57_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2845_ _2116_ _2198_ _2199_ _1975_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4515_ _1682_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__xor2_2
X_2776_ net150 _2131_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__and2_1
X_4446_ _1131_ _1132_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__xnor2_1
X_4377_ net86 net92 _1168_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__and3_1
X_3328_ _0513_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3259_ _0445_ _0430_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2630_ _2007_ _1989_ _2008_ net91 _2006_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__a32o_1
XFILLER_0_54_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2561_ _1952_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4300_ _1270_ _1443_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__xor2_2
X_2492_ _1793_ _1870_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__nor2_1
X_4231_ _1301_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_49_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4162_ _1311_ _1331_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__or2_1
X_3113_ _0288_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nand2_1
X_4093_ _1173_ _1262_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__o21a_1
X_3044_ _2302_ _2317_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3946_ _1111_ _1114_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__o21ai_1
X_3877_ _1033_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2828_ _1794_ _2038_ _2105_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2759_ _2116_ _2117_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__and2_1
X_4429_ _1593_ _1597_ _1598_ _1424_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_68_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout62 net63 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_6
Xfanout73 net74 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_12
Xfanout84 vec\[1\]\[6\] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_4
Xfanout95 net96 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_6
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3800_ _0925_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__xor2_1
XFILLER_0_51_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4780_ net271 _0193_ net178 VGND VGND VPWR VPWR slte0.opB\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3731_ _0902_ _0913_ _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3662_ net135 net136 VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__or2_1
X_2613_ _1915_ _1944_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__or2_1
X_3593_ net142 net145 VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__or2_1
X_2544_ _1762_ _1790_ _1860_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__and3_1
X_2475_ _1864_ _1866_ _1842_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4214_ _1168_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__or2b_4
X_4145_ _1247_ _1253_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__xnor2_2
X_4076_ _1161_ _1160_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__xnor2_1
X_3027_ _2323_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__xnor2_1
X_3929_ _1001_ _1088_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4672__86 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__inv_2
XFILLER_0_62_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4763_ net254 _0176_ net181 VGND VGND VPWR VPWR vec\[0\]\[12\] sky130_fd_sc_hd__dfstp_1
X_4694_ net185 _0107_ net175 VGND VGND VPWR VPWR state\[0\] sky130_fd_sc_hd__dfrtp_1
X_3714_ _0866_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3645_ _0824_ _0825_ _0696_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a21oi_1
X_3576_ _0749_ _0761_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2527_ _1917_ _1918_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__and2_1
X_2458_ net146 net144 net140 net138 net164 net161 VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__mux4_1
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold27 net32 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 net48 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 slte0.opA\[1\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
X_2389_ _1770_ _1766_ _1768_ _1780_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__and4bb_1
X_4128_ _1179_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__xor2_2
X_4059_ net68 net70 VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3430_ _0539_ _0552_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3361_ net128 _0541_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__nor2_1
X_3292_ _0477_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4746_ net237 _0159_ net178 VGND VGND VPWR VPWR slte0.opA\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3628_ _0811_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__xnor2_1
Xoutput39 net39 VGND VGND VPWR VPWR sin[11] sky130_fd_sc_hd__clkbuf_4
Xoutput28 net28 VGND VGND VPWR VPWR cos[3] sky130_fd_sc_hd__clkbuf_4
X_3559_ net143 net148 VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2930_ slte0.opA\[11\] _2271_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__nand2_2
X_4642__56 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__inv_2
X_2861_ _2210_ _2211_ _2212_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2792_ _2149_ _2150_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__and2_1
X_4531_ _1157_ _1678_ _1691_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4462_ _1631_ _1632_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3413_ _0568_ _0575_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4393_ net98 net100 VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__nand2_2
X_3344_ net134 _0528_ _0529_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__or3_1
X_3275_ _0434_ _0461_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_75_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4729_ net220 _0142_ net172 VGND VGND VPWR VPWR gm0.iter\[0\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_10_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3060_ _0252_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3962_ _1131_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__or2b_1
X_3893_ _1053_ _1059_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__and2b_1
X_2913_ _2251_ _2252_ _2253_ _2254_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__and4b_1
XFILLER_0_5_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2844_ _2116_ _2198_ _2199_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4514_ net54 net59 _1683_ _1684_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__a22o_1
X_2775_ _2133_ _2072_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4445_ _1610_ _1609_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__xor2_1
X_4376_ _1546_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__inv_2
X_3327_ net141 _0505_ _0512_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__or3_1
X_3258_ _0431_ _0427_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__and2b_1
X_3189_ _0374_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4612__26 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__inv_2
XFILLER_0_67_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2560_ _1886_ _1951_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2491_ net63 _1882_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4230_ _1386_ _1385_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__and2b_1
X_4161_ _1311_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3112_ _0285_ _0287_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__nand2_1
X_4092_ _1241_ _1261_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__or2_1
X_3043_ _1970_ _0239_ _0240_ net335 _2006_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a32o_1
XFILLER_0_77_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3945_ _1073_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3876_ _1045_ _1046_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__and2_1
X_2827_ net104 _1960_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2758_ net115 _2115_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__or2_1
X_4428_ _1425_ _1382_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__or2b_1
X_2689_ _2047_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4359_ _1515_ _1528_ _1529_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__a21bo_1
X_4678__92 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__inv_2
XFILLER_0_68_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout74 net75 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_12
Xfanout63 vec\[1\]\[13\] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout85 vec\[1\]\[5\] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_2
Xfanout96 vec\[1\]\[2\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3730_ _0910_ _0912_ _0914_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a22o_1
X_3661_ net135 net136 VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2612_ _1978_ net77 _1985_ _1995_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__a22o_1
X_3592_ net142 net145 VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nand2_1
X_2543_ net95 VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__inv_2
X_4587__1 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__inv_2
X_2474_ _1741_ _1865_ _1845_ _1830_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__a2bb2o_1
X_4213_ net80 net82 VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__nand2_1
X_4144_ _1308_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__or2_4
X_4075_ _1228_ _1234_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__xnor2_1
X_3026_ _2326_ _2279_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3928_ _1097_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3859_ net64 _1028_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4762_ net253 _0175_ net181 VGND VGND VPWR VPWR vec\[0\]\[11\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_70_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3713_ _0897_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__xnor2_1
X_3644_ _0821_ _0830_ _0824_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21o_1
X_3575_ _0750_ _0760_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__nor2_1
X_2526_ net85 _1916_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__or2_1
X_2457_ net155 _1847_ _1848_ _1842_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__o211a_1
Xhold17 net20 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 slte0.opA\[16\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 slte0.opA\[2\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
X_2388_ slte0.opB\[4\] _1765_ _1777_ slte0.opB\[3\] _1763_ VGND VGND VPWR VPWR _1780_
+ sky130_fd_sc_hd__o221a_1
X_4648__62 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__inv_2
X_4127_ net73 net76 VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__nand2_2
X_4058_ _1001_ _1218_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3009_ _1978_ slte0.opA\[14\] _0214_ _0215_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3360_ _0434_ _0541_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_29_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3291_ _0472_ _0476_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4745_ net236 _0158_ net177 VGND VGND VPWR VPWR slte0.opA\[11\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_16_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3627_ _0784_ _0812_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a21oi_1
Xoutput29 net29 VGND VGND VPWR VPWR cos[4] sky130_fd_sc_hd__clkbuf_4
X_3558_ _0739_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__xor2_1
X_2509_ net75 _1900_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__nor2_1
X_3489_ _0659_ _0657_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__and2b_1
XFILLER_0_34_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2860_ net167 net123 VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__or2_1
X_2791_ net132 _2148_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4530_ _1019_ _1688_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4461_ _1628_ _1629_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3412_ _0580_ _0593_ _0596_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4392_ _1555_ _1556_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__xor2_1
X_3343_ _0528_ _0529_ net134 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3274_ net124 net131 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_2
X_4618__32 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__inv_2
XFILLER_0_17_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2989_ _2269_ _2330_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__or2_1
X_4728_ net219 _0141_ net181 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3961_ _1055_ _1120_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__xnor2_1
X_2912_ _1827_ _1828_ _2247_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__o21ai_1
X_3892_ net56 net61 _1000_ _1025_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__and4_1
X_2843_ _2113_ _2181_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__and2b_1
X_2774_ net151 VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4513_ net58 _0999_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4444_ _1130_ _1136_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__xor2_1
X_4375_ net95 net97 VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__xnor2_2
X_3326_ _0505_ _0512_ net141 VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__o21ai_2
X_3257_ _0433_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3188_ _0363_ _0369_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__or2b_1
XFILLER_0_48_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2490_ _1801_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__xnor2_1
X_4160_ _1312_ _1329_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__a21oi_1
X_3111_ _0293_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4091_ _1241_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__xnor2_2
X_3042_ _2297_ _2318_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__or2_1
XFILLER_0_81_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3944_ _1065_ _1072_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3875_ _1044_ _1038_ _1042_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2826_ _2111_ _2113_ _2183_ _2109_ _2184_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__o311a_1
XFILLER_0_26_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2757_ net115 _2115_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2688_ net68 net66 net63 net60 net163 net159 VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__mux4_2
XFILLER_0_41_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4427_ _1418_ _1420_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__xnor2_1
X_4358_ _1527_ _1517_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__or2b_1
X_3309_ _0491_ _0487_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__and2b_1
X_4289_ net94 _1458_ _1459_ _1349_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__o22a_1
XFILLER_0_64_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout64 net65 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_6
Xfanout53 net54 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xfanout75 vec\[1\]\[9\] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_6
Xfanout86 vec\[1\]\[5\] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_4
Xfanout97 net99 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_2
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3660_ _0741_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2611_ _1906_ _1994_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__xnor2_1
X_3591_ _0558_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2542_ _1931_ _1932_ _1933_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_50_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4212_ _1357_ _1375_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__xnor2_2
X_2473_ net155 _1807_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4143_ _1307_ _1306_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__and2b_1
X_4074_ _1171_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__or2_1
X_3025_ _1970_ _2328_ _0227_ net337 _2006_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__a32o_1
X_3927_ _1001_ _1088_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3858_ net64 _0997_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nor2_1
X_3789_ net322 _0947_ _0967_ _0968_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__a22o_1
X_2809_ _2165_ _2161_ _2166_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_61_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4761_ net252 _0174_ net181 VGND VGND VPWR VPWR vec\[0\]\[10\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3712_ _0868_ _0880_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__o21a_1
X_3643_ _0822_ _0828_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a21oi_1
X_3574_ _0750_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nand2_1
X_2525_ net85 _1916_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__nand2_1
X_2456_ net155 _1814_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__nand2_1
Xhold29 net25 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 net41 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
X_4126_ net99 VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__inv_2
X_2387_ _1774_ _1776_ _1778_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__a21o_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4057_ _1177_ _1176_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4663__77 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__inv_2
X_3008_ _1981_ _2336_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3290_ _0472_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4744_ net235 _0157_ net177 VGND VGND VPWR VPWR slte0.opA\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3626_ _0783_ _0778_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__and2b_1
XFILLER_0_43_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3557_ net149 _0702_ _0742_ _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__o22a_1
Xoutput19 net19 VGND VGND VPWR VPWR cos[0] sky130_fd_sc_hd__clkbuf_4
X_2508_ _1821_ _1899_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__xnor2_1
X_3488_ _0647_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__xnor2_1
X_2439_ _1816_ _1828_ _1829_ _1830_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__a22o_1
X_4109_ _1008_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__xor2_1
XFILLER_0_66_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2790_ net132 _2148_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4460_ _1603_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__and2_1
X_3411_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__inv_2
X_4391_ _1542_ _1561_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3342_ _0435_ _0442_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3273_ _0434_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__inv_2
X_4633__47 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__inv_2
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2988_ _2263_ _2268_ slte0.opA\[12\] VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4727_ net218 _0140_ net180 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3609_ _0652_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3960_ _0994_ _1022_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__or2_1
X_2911_ _1839_ _2096_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3891_ net54 _1034_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_75_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2842_ _2118_ _2180_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2773_ net150 _2131_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__xor2_1
X_4512_ net56 net62 net54 VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_80_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4443_ _1612_ _1613_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4374_ _1165_ _1520_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__xor2_1
X_3325_ _0500_ _0507_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3256_ _0435_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__xnor2_1
X_3187_ _0368_ _0364_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__or2b_1
XFILLER_0_76_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3110_ _0291_ _0292_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__and2_1
X_4090_ _1242_ _1259_ _1260_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__a21oi_1
X_3041_ _2297_ _2318_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4603__17 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__inv_2
XFILLER_0_73_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3943_ _1104_ _1113_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__nor2_1
X_3874_ _1038_ _1042_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__o21ai_2
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2825_ net107 _2106_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2756_ _2114_ _2102_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2687_ net55 net156 _1804_ _2045_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4426_ _1489_ _1539_ _1594_ _1596_ _1456_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__o32a_1
X_4357_ _1517_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__xnor2_1
X_3308_ _0439_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__xnor2_2
X_4288_ _1351_ _1458_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__and2_1
X_3239_ net109 net112 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__xor2_2
XFILLER_0_68_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout65 net66 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_12
Xfanout54 net55 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_4
Xfanout76 net78 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_4
Xfanout87 vec\[1\]\[5\] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_4
Xfanout98 net99 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4669__83 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__inv_2
XFILLER_0_55_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2610_ _1909_ _1946_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__nor2_1
X_3590_ _0775_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nor2_1
X_2541_ net97 _1929_ _1930_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__and3_1
X_2472_ _1813_ _1839_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__nor2_1
X_4211_ _1378_ _1380_ _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4142_ _1245_ _1256_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__xor2_1
X_4073_ _1170_ _1169_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__and2b_1
X_3024_ _2325_ _0226_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__or2_1
X_3926_ _1094_ _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3857_ _1027_ _0997_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__xnor2_4
X_3788_ _2014_ _0964_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__nor2_1
X_2808_ _2165_ _2166_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__and2b_1
X_2739_ _1803_ _2095_ _2097_ _2035_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__o2bb2a_1
X_4409_ net77 net86 net88 net80 VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_64_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4760_ net251 _0173_ net179 VGND VGND VPWR VPWR vec\[0\]\[9\] sky130_fd_sc_hd__dfstp_1
X_3711_ _0877_ _0879_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3642_ _0823_ _0827_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3573_ _0752_ _0758_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2524_ _1837_ _1910_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__xor2_1
X_2455_ _1845_ _1846_ _1808_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__mux2_1
Xhold19 net21 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
X_2386_ slte0.opB\[3\] _1777_ _1775_ slte0.opB\[2\] VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__a22o_1
X_4125_ _1173_ _1262_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__xor2_2
X_4056_ _1215_ _1220_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3007_ _2335_ _2346_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3909_ _1079_ _1049_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4639__53 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4743_ net234 _0156_ net177 VGND VGND VPWR VPWR slte0.opA\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3625_ _0789_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__inv_2
X_3556_ net143 _0702_ net149 VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__a21bo_1
X_2507_ _1888_ _1893_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__nand2_1
X_3487_ _0660_ _0672_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a21oi_1
X_2438_ net154 net156 VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__nor2_4
X_2369_ _1757_ _1759_ _1760_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__a21o_1
X_4108_ net53 _1205_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__nand2_1
X_4039_ _1124_ _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3410_ _0586_ _0581_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4390_ _1543_ _1552_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__xor2_1
XFILLER_0_40_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3341_ _0441_ _0437_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__and2b_1
XFILLER_0_68_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3272_ _0390_ _0454_ _0448_ _2170_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_17_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2987_ slte0.opA\[11\] _2271_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4726_ net217 _0139_ net180 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3608_ net136 net142 _0610_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3539_ _0712_ _0724_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__o21a_1
X_4609__23 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__inv_2
XFILLER_0_79_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2910_ _1811_ _2075_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3890_ _1009_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2841_ _1981_ _2196_ _2197_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2772_ _2078_ _2130_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__xnor2_1
X_4511_ _1679_ _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__nand2_1
X_4442_ net82 _1608_ _1611_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__or3_1
X_4691__105 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__inv_2
X_4373_ net95 _1297_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__nor2_1
X_3324_ _0483_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__xnor2_1
X_3255_ _0437_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__xnor2_1
X_3186_ _0355_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4709_ net200 _0122_ net171 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_8_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3040_ _1970_ _0237_ _0238_ net334 _2006_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__a32o_1
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3942_ _1111_ _1112_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3873_ _1014_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2824_ _2118_ _2180_ _2182_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2755_ _1803_ _2046_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__nand2_1
X_2686_ _1808_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__and2_1
X_4425_ _1485_ _1486_ _1595_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4356_ _1523_ _1525_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__a21oi_1
X_3307_ net124 _0488_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__o21a_1
X_4287_ net85 net88 VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__nand2_1
X_3238_ _0267_ _0402_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__xnor2_1
X_3169_ net103 net106 _0286_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout55 vec\[1\]\[16\] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_2
XFILLER_0_64_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout66 vec\[1\]\[12\] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
Xfanout77 net78 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_8
Xfanout88 net89 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__buf_12
Xfanout99 vec\[1\]\[1\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_2
XFILLER_0_51_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4684__98 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__inv_2
XFILLER_0_59_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2540_ net101 _1856_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2471_ _1833_ _1837_ _1844_ _1862_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__and4bb_1
X_4210_ _1310_ _1332_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__xor2_1
X_4141_ net99 _1309_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4072_ _1226_ _1237_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__xor2_2
X_3023_ _2279_ _2323_ _2327_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o21a_1
X_3925_ net67 _1095_ net75 VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3856_ net58 net64 VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nand2_2
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3787_ _0957_ _0931_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__or2_1
X_2807_ net123 _2164_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2738_ _1865_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2669_ _2031_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
X_4408_ _1577_ _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__or2_1
X_4339_ _1496_ _1506_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3710_ _0892_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3641_ _0823_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__xor2_1
X_3572_ _0757_ _0753_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2523_ _1913_ _1914_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2454_ net144 net140 net138 net132 net164 net161 VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__mux4_1
X_2385_ slte0.opA\[3\] VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__inv_2
X_4124_ _1264_ _1294_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__and2b_1
Xinput1 in_valid VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_4055_ _1187_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3006_ _2266_ _2269_ _2332_ _2333_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__o31a_1
XFILLER_0_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3908_ _1045_ _1048_ _1021_ _1020_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a211oi_2
X_3839_ net58 _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4654__68 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__inv_2
XFILLER_0_69_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4742_ net233 _0155_ net177 VGND VGND VPWR VPWR slte0.opA\[8\] sky130_fd_sc_hd__dfrtp_1
X_3624_ _0803_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__xnor2_1
X_3555_ _0702_ _0741_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__nor2_1
X_2506_ _1896_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__nand2_1
X_3486_ _0661_ _0671_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2437_ net132 net129 net126 net123 net164 net160 VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2368_ slte0.opB\[11\] _1745_ _1755_ slte0.opB\[10\] VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__a22o_1
X_4107_ _1090_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4038_ net292 _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__xor2_4
XFILLER_0_66_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3340_ _0525_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nor2_1
X_3271_ net124 net131 VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__xor2_4
XFILLER_0_17_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2986_ _2279_ _2323_ _2325_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__o211ai_4
X_4725_ net216 _0138_ net181 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3607_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__inv_2
XFILLER_0_12_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3538_ _0713_ _0723_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__or2_1
X_3469_ _0654_ _0650_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4624__38 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__inv_2
XFILLER_0_66_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2840_ net167 net108 VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__or2_1
X_2771_ _1762_ _1790_ _2072_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4510_ net62 _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4441_ _1608_ _1611_ net82 VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4372_ _1523_ _1524_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__xnor2_2
X_3323_ _0498_ _0508_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__a21bo_1
X_3254_ _0438_ _0440_ net128 VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__mux2_1
X_3185_ _0361_ _0370_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2969_ _1791_ _2250_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4708_ net199 _0121_ net174 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3941_ _1110_ _1101_ _1108_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3872_ _1005_ _1013_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2823_ _2181_ _2116_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__nand2_1
X_2754_ net114 _2112_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2685_ net66 net63 net60 net57 net162 net159 VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4424_ _1427_ _1454_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4355_ _1522_ _1518_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__and2b_1
X_3306_ _0394_ _0488_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__or2b_1
X_4286_ _1434_ _1452_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__xnor2_2
X_3237_ _0322_ _0348_ _0352_ _0422_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a221o_1
X_3168_ _0336_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__or2_1
X_3099_ net105 net114 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__xor2_4
XFILLER_0_76_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout56 net57 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout67 net68 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_4
Xfanout78 vec\[1\]\[8\] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__buf_2
Xfanout89 net90 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_8
XFILLER_0_36_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2470_ _1849_ _1861_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__nor2_2
X_4140_ _1242_ _1259_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4071_ net96 _1172_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__xnor2_1
X_3022_ _0224_ _0225_ slte0.opA\[11\] _1978_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_25_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3924_ net65 net70 VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__xor2_4
XFILLER_0_18_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3855_ net61 _1025_ net69 VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_61_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3786_ _0258_ _0965_ _0966_ _0946_ net302 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a32o_1
XFILLER_0_73_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2806_ net123 _2164_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__nor2_1
X_2737_ _1841_ _1804_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2668_ slte0.opB\[3\] net12 _2017_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__mux2_1
X_4407_ _1557_ _1558_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__xor2_1
X_2599_ _1891_ _1950_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__nand2_1
X_4338_ _1297_ _1490_ _1508_ _1494_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__a31o_1
X_4269_ _1343_ _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_37_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3640_ _0696_ _0824_ _0825_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a31o_1
X_3571_ _0753_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__xnor2_2
X_2522_ net83 _1912_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__or2_1
X_2453_ net129 net126 net123 net122 net164 net160 VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__mux4_1
X_2384_ slte0.opB\[2\] _1775_ _1772_ slte0.opB\[1\] VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__o22a_1
X_4123_ _1188_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__xor2_2
X_4054_ _1186_ _1185_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__and2b_1
Xinput2 rstb VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_2
X_3005_ _1970_ _2344_ _2345_ net338 _2006_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__a32o_1
XFILLER_0_78_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3907_ _1077_ _1076_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3838_ net53 _1008_ _0994_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_6_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3769_ net326 _0947_ _0953_ net340 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4741_ net232 _0154_ net177 VGND VGND VPWR VPWR slte0.opA\[7\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3623_ _0807_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3554_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2505_ net295 _1895_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__or2_1
X_3485_ _0661_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__nand2_1
X_2436_ net154 _1807_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__nor2_2
X_2367_ slte0.opB\[9\] _1756_ _1758_ slte0.opB\[8\] VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__a22o_1
X_4106_ _0992_ _1052_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__xnor2_1
X_4037_ net62 net65 VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__nand2_2
XFILLER_0_34_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3270_ _0446_ _0451_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__and3_1
XFILLER_0_17_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4724_ net215 _0137_ net181 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2985_ _2326_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4586_ _1981_ _1738_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__nand2_1
X_3606_ net146 net150 VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__xnor2_1
X_3537_ _0713_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3468_ _0650_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__and2b_1
X_3399_ _0582_ _0583_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__o21ba_1
X_2419_ net152 net154 VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2770_ net144 _2128_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__or2_1
X_4440_ _1609_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_44_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4371_ net95 net97 VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__nand2_1
X_3322_ _0497_ _0485_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3253_ _0394_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__xnor2_2
X_3184_ _0283_ _0360_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_53_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2968_ slte0.opA\[0\] _2249_ _2308_ _2309_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__a31o_1
XFILLER_0_71_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4707_ net198 _0120_ net174 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_62_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2899_ net152 net158 _2240_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__or3_4
X_4569_ net315 _0946_ _1728_ _0258_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_71_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4592__6 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__inv_2
XFILLER_0_81_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3940_ _1101_ _1108_ _1110_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__a21oi_1
X_3871_ _1040_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2822_ net114 _2112_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2753_ _2043_ _2103_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2684_ _1795_ _2042_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__nand2_1
X_4423_ _1513_ _1531_ _1536_ _1538_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__a31oi_1
X_4354_ _1524_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__inv_2
X_3305_ _0487_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__xnor2_2
X_4285_ _1383_ _1417_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__xnor2_2
X_3236_ _0351_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__inv_2
X_3167_ _0264_ _0335_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__and2_1
X_3098_ net111 _0283_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout68 net69 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_6
Xfanout79 vec\[1\]\[7\] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__buf_4
Xfanout57 vec\[1\]\[15\] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_55_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4070_ _1190_ _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__xnor2_1
X_3021_ _2276_ _2328_ _0223_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a21oi_1
X_4675__89 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__inv_2
X_3923_ _1089_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3854_ net58 net64 VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__xor2_4
XFILLER_0_46_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2805_ _2056_ _2099_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__xnor2_1
X_3785_ _0930_ _0419_ _0964_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__or3_1
XFILLER_0_61_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2736_ _2068_ _2044_ net156 VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2667_ _2030_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
X_4406_ _1562_ _1563_ _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__and3_1
X_2598_ _1969_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ net100 _1507_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__nand2_1
X_4268_ _1430_ _1429_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__and2b_1
X_3219_ _0400_ _0403_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nor2_1
X_4199_ _1368_ _1364_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__and2b_1
XFILLER_0_9_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3570_ _0440_ _0755_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a21oi_1
X_2521_ net83 _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2452_ _1822_ _1809_ _1843_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2383_ slte0.opA\[2\] VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__inv_2
X_4122_ _1290_ _1292_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__xnor2_2
X_4053_ _1202_ _1223_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__xnor2_2
Xinput3 theta[0] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3004_ _2262_ _2336_ _2343_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__or3b_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3906_ _1074_ _1071_ _1073_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__or3_1
X_3837_ net57 net59 VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__xnor2_4
X_3768_ _0281_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2719_ _1841_ net155 _2055_ _2077_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__a31o_1
X_3699_ _0882_ _0881_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4687__101 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__inv_2
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4645__59 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4740_ net231 _0153_ net177 VGND VGND VPWR VPWR slte0.opA\[6\] sky130_fd_sc_hd__dfrtp_1
X_3622_ _0558_ _0777_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3553_ net143 net148 VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__and2_1
X_2504_ net295 _1895_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__nand2_1
X_3484_ _0663_ _0669_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a21boi_2
X_2435_ _1822_ net157 VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__nor2_2
X_4105_ _1023_ _1204_ _1206_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__a21o_1
X_2366_ slte0.opA\[8\] VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4036_ _1023_ _1204_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2984_ slte0.opA\[9\] _2278_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__nor2_1
X_4723_ net214 _0136_ net181 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4585_ net333 _1738_ net340 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a21o_1
X_3605_ _0606_ _0781_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__xor2_1
X_3536_ _0715_ _0721_ _0722_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3467_ net142 _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a21oi_1
X_3398_ _0530_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nor2_1
X_2418_ _1803_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__nand2_1
X_2349_ _1739_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__nand2_1
X_4019_ _1188_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4615__29 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__inv_2
XFILLER_0_57_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4370_ _1537_ _1540_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__nand2_1
X_3321_ _0500_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__xnor2_2
X_3252_ net121 net128 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nand2_2
X_3183_ _0363_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__xnor2_1
X_2967_ slte0.opA\[1\] _2307_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4706_ net197 _0119_ net171 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfrtp_1
X_2898_ net162 VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4568_ _1725_ _1652_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__xor2_1
X_4499_ _1655_ _1669_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__and2_1
X_3519_ _0703_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3870_ _1035_ _1037_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2821_ _2169_ _2174_ _2177_ _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__a31o_1
X_2752_ _2109_ _2110_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4422_ _1489_ _1541_ _1592_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__or3_4
X_2683_ net63 net60 net57 net55 net162 net158 VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__mux4_2
XFILLER_0_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4353_ _1463_ _1507_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3304_ _0283_ _0490_ _0324_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a21oi_2
X_4284_ _1427_ _1454_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3235_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__inv_2
X_3166_ _0338_ _0340_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__xnor2_2
X_3097_ net111 _0265_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3999_ _1162_ _1167_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__xor2_1
Xfanout58 net60 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_8
Xfanout69 vec\[1\]\[11\] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3020_ _2276_ _2328_ _0223_ _1975_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a31o_1
X_3922_ net72 _1091_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__a21oi_1
X_3853_ net61 _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__nor2_1
X_2804_ _2161_ _2162_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__and2_1
X_3784_ _0419_ _0964_ _0930_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_14_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2735_ _1842_ _2093_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__nand2_1
X_2666_ slte0.opB\[4\] net13 _2017_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__mux2_1
X_4405_ _1564_ _1574_ _1575_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__o21ai_1
X_2597_ _1954_ _1981_ _1983_ _1984_ net168 VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o32ai_1
X_4336_ net92 net94 VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__and2_2
XFILLER_0_5_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4267_ _1402_ _1409_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__xnor2_4
X_3218_ _0395_ _0396_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__xnor2_1
X_4198_ _1364_ _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__xnor2_2
X_3149_ _0264_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2520_ _1833_ _1911_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2451_ _1824_ _1839_ _1840_ net341 _1842_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__o221a_1
X_2382_ slte0.opB\[1\] _1772_ _1773_ slte0.opB\[0\] VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__a211o_1
X_4121_ _1190_ _1240_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__a21oi_2
X_4052_ _1214_ _1222_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__xnor2_2
Xinput4 theta[10] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_3003_ _2262_ _2336_ _2343_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_78_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3905_ _1075_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3836_ net56 _1000_ net61 VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__o21a_1
X_3767_ _0934_ _0937_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2718_ _1808_ _2057_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__o21a_1
X_3698_ _0843_ _0883_ _0859_ _0861_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__o2bb2a_1
X_2649_ _2021_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4319_ net88 net91 VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3621_ net130 net136 _0499_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__and3_1
X_3552_ net137 net144 _0737_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a31o_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2503_ _1818_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3483_ _0664_ _0668_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nand2_1
X_2434_ _1808_ _1805_ _1823_ _1825_ _1803_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a32o_1
X_2365_ slte0.opB\[10\] _1755_ _1756_ slte0.opB\[9\] VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__o22a_1
X_4104_ _1273_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__xnor2_2
X_4035_ net53 _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3819_ net56 net59 VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4799_ net290 _0212_ net172 VGND VGND VPWR VPWR vec\[1\]\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2983_ _2276_ _2324_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4722_ net213 _0135_ net181 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4584_ net296 _1738_ net340 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a21o_1
X_3604_ net145 net148 VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3535_ _0716_ _0720_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3466_ net142 _0610_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__nor2_1
X_2417_ _1805_ _1806_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__mux2_1
X_3397_ _0582_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__xnor2_1
X_2348_ net107 net104 net163 VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4018_ net93 _1184_ _1187_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__or3_1
XFILLER_0_62_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3320_ _0505_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3251_ _0394_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__inv_2
X_3182_ _0364_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2966_ _1772_ _2307_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__xnor2_1
X_4705_ net196 _0118_ net174 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
X_2897_ _2237_ _2238_ slte0.opA\[15\] VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__o21a_1
XFILLER_0_71_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4567_ net307 _0946_ _1727_ _0258_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a22o_1
X_4498_ _1662_ _1667_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__a21o_1
X_3518_ _0699_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__nor2_1
X_3449_ _0614_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_9_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2820_ net118 _2176_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2751_ net110 _2108_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2682_ _1795_ _2040_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__nand2_1
X_4421_ _1559_ _1560_ _1591_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4352_ _1518_ _1522_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__xnor2_2
X_3303_ _0488_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__and2_1
X_4283_ _1434_ _1452_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__a21oi_2
X_3234_ _0385_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3165_ _0350_ _0322_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__and3b_1
X_3096_ _0265_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_49_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3998_ net87 _1168_ net93 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__o21ai_1
Xfanout59 net60 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_2
X_2949_ slte0.opA\[6\] _2289_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3921_ net72 _1052_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__nor2_1
X_3852_ net58 _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nand2_2
X_4596__10 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
XFILLER_0_18_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2803_ net126 _2160_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3783_ _0957_ _0931_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2734_ _1828_ _2047_ _2061_ _1830_ _2092_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__a221o_1
X_2665_ _2029_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
X_2596_ net65 VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__inv_2
X_4404_ _1565_ _1573_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4335_ _1498_ _1504_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__o21a_1
X_4266_ _1434_ _1436_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__or2_1
X_3217_ _0400_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__nand2_1
X_4197_ _1125_ _1366_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__a21oi_2
X_3148_ _0331_ _0332_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__xnor2_1
X_3079_ net105 _0265_ net111 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_68_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4680__94 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__inv_2
XFILLER_0_43_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2450_ _1841_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__clkbuf_4
X_2381_ slte0.opA\[0\] VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__inv_2
X_4120_ _1224_ _1239_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__and2_1
X_4051_ _1215_ _1220_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__o21ai_2
Xinput5 theta[11] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_3002_ _2337_ _2342_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3904_ _1071_ _1073_ _1074_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__o21a_1
XFILLER_0_52_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3835_ net56 net59 VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3766_ net325 _0947_ _0949_ net340 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a22o_1
X_2717_ _2073_ _2074_ _2064_ _2075_ _1802_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__o221a_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3697_ _0843_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__or2_1
X_2648_ slte0.opB\[13\] net7 _2018_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__mux2_1
X_2579_ _1968_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__clkbuf_4
X_4318_ _1455_ _1456_ _1487_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__a211o_1
X_4249_ _1380_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3620_ _0467_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3551_ net140 _0736_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2502_ _1821_ _1893_ _1888_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__o21ai_1
X_3482_ _0664_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__xor2_2
X_2433_ _1806_ _1824_ _1808_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux2_1
X_2364_ slte0.opA\[9\] VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__inv_2
X_4103_ net76 _1159_ net84 VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__o21ai_2
X_4034_ net58 net62 VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3818_ _0950_ _0921_ _0989_ _0975_ net299 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__a32o_1
X_4798_ net289 _0211_ net171 VGND VGND VPWR VPWR vec\[1\]\[14\] sky130_fd_sc_hd__dfrtp_1
X_3749_ _0934_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4650__64 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__inv_2
XFILLER_0_65_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2982_ slte0.opA\[10\] _2275_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__or2_1
X_4721_ net212 _0134_ net181 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_1
X_3603_ _0784_ _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__xnor2_2
X_4583_ _1968_ net1 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__nand2_1
X_3534_ _0716_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__xor2_2
X_3465_ _0610_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__xnor2_2
X_2416_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3396_ _0527_ _0532_ _0525_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a21oi_1
X_2347_ net158 VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4017_ _1184_ _1187_ net93 VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3250_ net120 _0428_ _0429_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a2bb2o_1
X_3181_ _0365_ _0367_ net122 VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4704_ net195 _0117_ net174 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
X_2965_ _2246_ _2306_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2896_ net152 _1794_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4566_ _1646_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3517_ _0694_ _0698_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__nor2_1
X_4497_ _1661_ _1658_ _1660_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__nor3_1
X_3448_ net147 _0609_ _0613_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__and3b_1
X_3379_ _0556_ _0560_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_40_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4620__34 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__inv_2
XFILLER_0_35_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2750_ net110 _2108_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2681_ net55 _1797_ _2039_ _1739_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4420_ _1513_ _1559_ _1579_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4351_ _1165_ _1520_ _1521_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__a21oi_2
X_3302_ net116 net120 VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__or2_1
X_4282_ _1451_ _1435_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__and2b_1
X_3233_ _0386_ _0419_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__or2b_1
X_3164_ _0317_ _0320_ _0295_ _0296_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__a211o_1
X_3095_ net105 net111 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__nand2_2
XFILLER_0_76_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3997_ net83 net88 VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__xor2_4
XFILLER_0_57_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2948_ slte0.opA\[6\] _2289_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2879_ _2223_ _2141_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__or2_1
X_4549_ _1712_ _1152_ _1711_ _2014_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3920_ _1052_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__xnor2_4
X_3851_ net53 net56 VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3782_ _0258_ _0959_ _0963_ _0946_ net308 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a32o_1
X_2802_ net126 _2160_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__nand2_1
X_2733_ _1865_ _2037_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2664_ slte0.opB\[5\] net14 _2017_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__mux2_1
X_2595_ _1952_ _1891_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__and3_1
X_4403_ _1565_ _1573_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4334_ _1503_ _1499_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__or2b_1
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4265_ _1431_ _1433_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3216_ _0267_ _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__nand2_1
X_4196_ net68 net345 _1095_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__and3_1
X_3147_ _0329_ _0333_ net125 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o21ai_2
X_3078_ net102 net108 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__xor2_4
XFILLER_0_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2380_ slte0.opA\[1\] VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__inv_2
X_4050_ _1216_ _1219_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__or2_1
Xinput6 theta[12] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_3001_ _2239_ VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__inv_2
X_4656__70 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__inv_2
X_3903_ _1033_ _1047_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3834_ _0996_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__xnor2_1
X_3765_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2716_ net156 net159 VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__or2b_1
X_3696_ _0881_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2647_ _2020_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2578_ _1969_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__buf_4
XFILLER_0_10_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4317_ _1455_ _1456_ _1485_ _1486_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__a2bb2o_4
X_4248_ _1355_ _1379_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__and2_1
X_4179_ net88 net94 VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_33_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3550_ _0610_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__or2b_1
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2501_ _1888_ _1868_ _1826_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__a21o_1
X_3481_ _0367_ _0666_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2432_ net126 net123 net122 net118 net164 net161 VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__mux4_2
X_2363_ slte0.opA\[10\] VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__inv_2
X_4102_ _1269_ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4033_ net53 _1008_ _1203_ _0994_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a211o_1
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4797_ net288 _0210_ net173 VGND VGND VPWR VPWR vec\[1\]\[13\] sky130_fd_sc_hd__dfrtp_1
X_3817_ _0773_ _0987_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a21o_1
X_3748_ _0295_ _0933_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3679_ _0865_ _0788_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4595__9 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__inv_2
X_4626__40 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__inv_2
X_2981_ _2283_ _2286_ _2321_ _2322_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__a31o_2
X_4720_ net211 _0133_ net183 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3602_ _0788_ _0779_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__xor2_2
X_4582_ _0950_ _1723_ _1737_ _0945_ net317 VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a32o_1
X_3533_ _0391_ _0718_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_12_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3464_ net136 net144 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__nand2_2
X_2415_ net157 VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__inv_2
X_3395_ _0411_ _0413_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__xnor2_1
X_4016_ _1185_ _1186_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3180_ _0366_ _0330_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2964_ _1762_ _1790_ _2249_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__and3_1
X_4703_ net194 _0116_ net174 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_29_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2895_ net341 _2096_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4565_ _1725_ _1652_ _1650_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a21bo_1
X_3516_ net143 _0702_ net149 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4496_ _1666_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__inv_2
X_3447_ _0618_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__xnor2_1
X_3378_ _0538_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2680_ net60 net57 net162 VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4350_ net84 net88 _1163_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__and3_1
X_3301_ net116 net120 VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4281_ _1435_ _1451_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3232_ _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__and2b_1
X_3163_ _0349_ _0347_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__xnor2_1
X_3094_ _0277_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__xor2_1
XFILLER_0_76_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3996_ net344 _1165_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a21oi_1
X_2947_ _1792_ _2273_ _2288_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__mux2_1
X_2878_ _2223_ _2141_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__nand2_1
X_4548_ _1152_ _1711_ _1712_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__a21oi_1
X_4479_ _1647_ _1648_ _1649_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3850_ _1014_ _1018_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3781_ _0958_ _0421_ _0350_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__nand3_1
X_2801_ _2098_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__xnor2_1
X_2732_ _2087_ _2090_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2663_ _2028_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_2594_ _1950_ _1949_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__nand2_1
X_4402_ net97 _1566_ _1571_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__o31a_1
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4333_ _1499_ _1503_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__and2b_1
X_4264_ _1399_ _1412_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__xor2_2
X_3215_ _0325_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__xnor2_1
X_4195_ _1339_ _1365_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__and2_1
X_3146_ _0331_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nor2_1
X_3077_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3979_ _1147_ _1149_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput7 theta[13] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_3000_ _1970_ _2339_ _2341_ net319 _2006_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__a32o_1
X_4671__85 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__inv_2
X_3902_ _1065_ _1072_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__nor2_1
X_3833_ _0998_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3764_ _2233_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2715_ net157 net160 VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__or2_1
X_3695_ _0854_ _0857_ _0845_ _0858_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__o22a_1
XFILLER_0_42_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2646_ slte0.opB\[14\] net8 _2018_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2577_ _1968_ _1853_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__nor2_2
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4316_ _1485_ _1486_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__nor2_1
X_4247_ _1383_ _1417_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nor2_1
X_4178_ net91 net99 VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__nand2_1
X_3129_ _0311_ _0314_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2500_ _1891_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3480_ _0436_ _0330_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and2_1
X_2431_ net153 _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__nor2_1
X_2362_ _1750_ _1752_ _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__and3b_1
X_4101_ net81 _1270_ _1271_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__a21oi_2
X_4032_ net62 net64 VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4796_ net287 _0209_ net173 VGND VGND VPWR VPWR vec\[1\]\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3816_ _0771_ _0918_ _0920_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__and3b_1
X_3747_ _0295_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__and2_1
X_3678_ net145 _0804_ _0846_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__o22a_1
X_2629_ _1928_ _1940_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2980_ slte0.opA\[8\] _2282_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__and2_1
X_4641__55 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__inv_2
XFILLER_0_33_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput10 theta[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_3601_ _0786_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__nor2_2
X_4581_ _1722_ _1598_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3532_ net120 net124 _0362_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__nand3_1
X_3463_ net133 _0648_ _0649_ _0557_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__o22a_1
X_2414_ net116 net113 net110 net107 net166 net160 VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__mux4_1
X_3394_ _0398_ _0415_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4015_ _1178_ _1183_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__xor2_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4779_ net270 _0192_ net178 VGND VGND VPWR VPWR slte0.opB\[11\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_79_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2963_ _1777_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4702_ net193 _0115_ net176 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
X_2894_ _2236_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4564_ _1724_ _1424_ _1337_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_8_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3515_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__clkbuf_2
X_4495_ _1663_ _1664_ _1665_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__o21a_1
X_3446_ _0629_ _0631_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3377_ _0553_ _0562_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4611__25 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__inv_2
XFILLER_0_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3300_ _0264_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__xnor2_2
X_4280_ _1437_ _1449_ _1450_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__o21a_1
X_3231_ _0381_ _0382_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__xor2_2
XFILLER_0_39_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3162_ _0320_ _0323_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__and2_1
X_3093_ net102 net108 _0278_ _0279_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_49_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3995_ net344 _1163_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2946_ _1865_ _2241_ _2252_ _2287_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__o211a_1
XFILLER_0_72_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2877_ _2142_ _2129_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4547_ _1674_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4478_ _1266_ _1642_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__xor2_1
X_3429_ _0615_ _0570_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__xnor2_1
X_4677__91 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__inv_2
XFILLER_0_63_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3780_ _0258_ _0960_ _0962_ _0946_ net310 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a32o_1
XFILLER_0_73_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2800_ _2091_ _2094_ _1793_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__a21o_1
X_2731_ net153 _2089_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2662_ slte0.opB\[6\] net15 _2018_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__mux2_1
X_4401_ _1570_ _1567_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__or2b_1
X_2593_ _1975_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__buf_4
X_4332_ _1181_ _1501_ _1502_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__a21oi_1
X_4263_ _1431_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__and2_1
X_3214_ _0259_ _0301_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_19_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4194_ net78 net80 VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__or2_1
X_3145_ _0324_ _0328_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__xnor2_1
X_3076_ _0261_ _0262_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3978_ _1146_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2929_ _2259_ _1794_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 theta[14] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3901_ _1051_ _1070_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__xor2_1
X_3832_ net61 _1001_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3763_ _0939_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__xnor2_1
X_2714_ net97 net95 net165 VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__mux2_1
X_3694_ _0868_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xor2_1
X_2645_ _2019_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4315_ _1427_ _1454_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__xor2_1
X_2576_ _1967_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__buf_4
X_4246_ _1397_ _1415_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__a21oi_2
X_4177_ _1342_ _1346_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__xor2_1
X_3128_ _0300_ _0310_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4647__61 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__inv_2
X_3059_ _2014_ _0250_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2430_ net154 VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__inv_2
X_2361_ _1751_ slte0.opA\[12\] VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__nand2_1
X_4100_ net81 _1175_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__nor2_1
X_4031_ _1200_ _1201_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4795_ net286 _0208_ net173 VGND VGND VPWR VPWR vec\[1\]\[11\] sky130_fd_sc_hd__dfrtp_1
X_3815_ _0771_ _0772_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__or2_1
X_3746_ _0273_ _0276_ _0277_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3677_ net142 net148 VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__nand2_1
X_2628_ _1928_ _1940_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__nand2_1
X_2559_ net66 _1885_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__nor2_1
X_4229_ _1363_ _1369_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_65_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4580_ _1735_ _1736_ net328 _0947_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a2bb2o_1
Xinput11 theta[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_3600_ net145 net151 VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__nor2_1
X_3531_ _0691_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3462_ _0499_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__and2b_1
X_3393_ _0537_ _0578_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__o21ba_1
X_2413_ net104 _1804_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4617__31 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__inv_2
X_4014_ net82 _1163_ net344 VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_74_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4778_ net269 _0191_ net178 VGND VGND VPWR VPWR slte0.opB\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3729_ _0903_ _0909_ _0915_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2962_ _2258_ _2303_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__xnor2_1
X_4701_ net192 _0114_ net176 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_44_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2893_ _2233_ _2234_ _2235_ VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__or3_1
XFILLER_0_44_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4563_ _1382_ _1421_ _1723_ _1425_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__a31o_1
XFILLER_0_69_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4494_ _1612_ _1659_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__xor2_1
X_3514_ _0695_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and2_1
X_3445_ _0619_ _0628_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nor2_1
X_3376_ _0539_ _0552_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3230_ _0398_ _0415_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__o21ba_1
X_3161_ _0320_ _0323_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__and3_1
X_3092_ net105 net111 net108 VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_49_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3994_ _1163_ _1164_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2945_ _1828_ _2247_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2876_ _1970_ _2221_ _2222_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a21oi_1
X_4546_ _1676_ _1704_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4477_ _1188_ _1293_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3428_ _0538_ _0564_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__xnor2_1
X_3359_ _0540_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_13_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2730_ _1827_ _2040_ _2088_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__a21oi_1
X_2661_ _2027_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
X_4400_ _1567_ _1570_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2592_ _1970_ _1979_ _1980_ net63 _1971_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__a32o_1
XFILLER_0_1_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4331_ net79 net86 _1179_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4262_ net100 _1393_ _1394_ _1432_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__o22a_1
X_3213_ net103 _0304_ _0360_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4193_ _1091_ _1320_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__xor2_2
X_3144_ net115 _0330_ net122 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__o21ai_1
X_3075_ net106 net109 net103 VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nand3b_1
X_3977_ _1145_ _1139_ _1144_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__and3_1
X_2928_ _2253_ _2260_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2859_ _2209_ _2167_ _1975_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4529_ _0950_ _1696_ _1698_ _0975_ net303 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__a32o_1
XFILLER_0_36_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 theta[15] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_3900_ _1051_ _1070_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__and2b_1
X_3831_ net61 _1000_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__nor2_1
X_3762_ _0264_ _0941_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__nor2_1
X_2713_ net55 _1853_ _2071_ _1841_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__a22o_2
X_3693_ _0877_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__xnor2_1
X_2644_ slte0.opB\[15\] net9 _2018_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__mux2_1
X_2575_ net169 VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__inv_2
X_4314_ _1457_ _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4245_ _1414_ _1398_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__and2b_1
X_4176_ _1342_ _1346_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__and2_1
X_3127_ net122 _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__xnor2_1
X_4662__76 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__inv_2
X_3058_ net168 _2249_ slte0.opA\[0\] VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_47_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2360_ _1746_ slte0.opA\[13\] slte0.opA\[12\] _1751_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ _1199_ _1191_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3814_ net323 _0946_ _0986_ net340 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__a22o_1
X_4794_ net285 _0207_ net173 VGND VGND VPWR VPWR vec\[1\]\[10\] sky130_fd_sc_hd__dfrtp_1
X_3745_ _0599_ _0929_ _0930_ _0931_ _0352_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_15_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3676_ _0801_ _0839_ _0842_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a211o_1
XFILLER_0_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2627_ _2004_ _1989_ _2005_ net89 _2006_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a32o_1
X_2558_ net69 _1890_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__or2_1
X_2489_ _1810_ _1870_ _1794_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__a21oi_1
X_4228_ _1392_ _1395_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_74_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4159_ _1328_ _1313_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput12 theta[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
X_3530_ net127 net130 VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3461_ net124 net128 VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__nand2_1
X_3392_ _0536_ _0518_ _0520_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__nor3_1
X_2412_ net158 net162 VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__nor2_1
X_4013_ _1178_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4632__46 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__inv_2
XFILLER_0_59_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4777_ net268 _0190_ net177 VGND VGND VPWR VPWR slte0.opB\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3728_ _0908_ _0905_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__and2b_1
X_3659_ _0702_ _0804_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__xor2_1
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2961_ _1792_ _2256_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4700_ net191 _0113_ net176 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_29_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2892_ net169 _2072_ _2133_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4562_ _1722_ _1598_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__or2_1
X_4493_ _1603_ _1635_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__nor2_1
X_3513_ net141 net146 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3444_ _0613_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__and2_1
X_3375_ _0555_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_67_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3160_ _0334_ _0346_ _0344_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__o21ai_1
X_3091_ net105 net111 net102 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3993_ net82 net90 VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__nand2_1
X_4602__16 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__inv_2
X_2944_ slte0.opA\[7\] _2285_ VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__or2_1
X_2875_ net170 net140 VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4545_ _0950_ _1707_ _1710_ _0975_ net306 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__a32o_1
XFILLER_0_52_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4476_ _1290_ _1292_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__nor2_1
X_3427_ _0609_ _0613_ net147 VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__a21boi_2
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3358_ _0304_ _0543_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21oi_2
X_3289_ _0474_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4668__82 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2660_ slte0.opB\[7\] net16 _2018_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ _1883_ _1955_ _1886_ _1954_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4330_ _1490_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__and2_1
X_4261_ net94 net100 _1393_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__and3_1
X_3212_ _0373_ _0377_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__xnor2_1
X_4192_ _1164_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__xnor2_1
X_3143_ net112 net119 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__xor2_4
X_3074_ net103 net109 net106 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_49_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3976_ net81 _1141_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__nand2_1
X_2927_ slte0.opA\[12\] _2263_ _2268_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2858_ _2209_ _2167_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2789_ _2090_ _2147_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__xor2_1
X_4528_ _1695_ _1692_ _1694_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__nand3_1
X_4459_ net87 _1601_ _1602_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3830_ _0999_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_46_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3761_ _0945_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__clkbuf_8
X_2712_ _2068_ _2044_ _2069_ _2070_ net156 _1822_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__mux4_1
X_3692_ _0847_ _0853_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a21oi_1
X_2643_ _2017_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2574_ _1875_ _1877_ _1959_ _1964_ _1874_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__o311ai_1
XFILLER_0_77_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4313_ _1464_ _1482_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_77_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4244_ _1398_ _1414_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__xnor2_2
X_4175_ net96 _1344_ _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__a21oi_1
X_3126_ net112 _0307_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__o21ba_1
X_3057_ _1968_ _1773_ _2249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__or3b_1
XFILLER_0_9_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3959_ _1127_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__xor2_2
XFILLER_0_60_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4638__52 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__inv_2
XFILLER_0_24_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3813_ _0983_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nor2_1
X_4793_ net284 _0206_ net173 VGND VGND VPWR VPWR vec\[1\]\[9\] sky130_fd_sc_hd__dfrtp_1
X_3744_ _0418_ _0417_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3675_ _0817_ _0820_ _0859_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a22o_1
X_2626_ _1968_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__buf_4
X_2557_ _1898_ _1901_ _1948_ _1896_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__o31ai_4
X_2488_ _1879_ _1875_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__nor2_1
X_4227_ _1360_ _1372_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__xor2_2
X_4158_ _1313_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__xnor2_1
X_3109_ _0290_ _0293_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nor2_1
X_4089_ _1258_ _1243_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput13 theta[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_3460_ _0646_ _0631_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__xnor2_1
X_3391_ _0574_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__o21a_1
X_2411_ _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4012_ net87 _1181_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_79_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4776_ net267 _0189_ net177 VGND VGND VPWR VPWR slte0.opB\[8\] sky130_fd_sc_hd__dfrtp_1
X_3727_ _0767_ _0768_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xor2_1
X_3658_ _0843_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__or2_1
X_2609_ _1978_ net74 _1985_ _1993_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__a22o_1
X_3589_ net139 net142 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nor2_1
X_4608__22 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__inv_2
XFILLER_0_78_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2960_ _2300_ _2301_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__nand2_1
X_2891_ net169 _2133_ _2072_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4561_ _1593_ _1597_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4492_ _1626_ _1634_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__nor2_1
X_3512_ _0694_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__and2_1
X_3443_ _0611_ _0612_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand2_1
X_3374_ _0556_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4759_ net250 _0172_ net179 VGND VGND VPWR VPWR vec\[0\]\[8\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_70_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4690__104 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__inv_2
XFILLER_0_81_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3090_ net115 _0270_ _0273_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__o2bb2a_1
X_4599__13 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__inv_2
X_3992_ net79 net86 VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__xor2_4
X_2943_ _1793_ _2259_ _2284_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2874_ _2126_ _2143_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4544_ _1078_ _1706_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4475_ _1644_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3426_ _0611_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__or2_1
X_3357_ net109 net117 _0286_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3288_ net138 _0473_ _0465_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4683__97 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__inv_2
XFILLER_0_73_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2590_ _1956_ _1883_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__or2b_1
X_4260_ net88 net94 _1429_ _1430_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__a31o_1
X_3211_ _0393_ _0397_ net131 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__o21ai_2
X_4191_ net87 _1339_ _1340_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__o21a_1
X_3142_ _0324_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__and2_1
X_3073_ net102 _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__nand2_1
X_3975_ _1139_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a21oi_2
X_2926_ _1793_ _2267_ VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__xnor2_1
X_2857_ _2158_ _2163_ _2161_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_72_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2788_ _1888_ _2087_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__nand2_1
X_4527_ net314 _0946_ _1697_ net340 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__a22o_1
X_4458_ _1275_ _1283_ _1282_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__a21o_1
X_3409_ _0594_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__nor2_1
X_4389_ _1513_ _1531_ _1536_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3760_ _0258_ _0940_ _0944_ _0946_ net320 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__a32o_1
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2711_ net89 net85 net83 net79 net165 net160 VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__mux4_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3691_ _0852_ _0851_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__and2b_1
XFILLER_0_54_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2642_ _2016_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2573_ _1874_ _1878_ _1880_ _1959_ _1964_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a221o_1
X_4588__2 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__inv_2
XFILLER_0_10_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4312_ _1465_ _1481_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__or2b_1
X_4243_ _1399_ _1412_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__o21a_1
X_4174_ net96 _1305_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__nor2_1
X_3125_ _0302_ _0308_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__and2b_1
X_3056_ _1989_ _0248_ _0249_ net329 _1968_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__a32o_1
XFILLER_0_26_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3958_ net295 _1128_ net78 VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__o21ai_2
X_3889_ _1053_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2909_ _1808_ _2241_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4653__67 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__inv_2
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3812_ _0733_ _0735_ _0773_ _0921_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__o211a_1
X_4792_ net283 _0205_ net173 VGND VGND VPWR VPWR vec\[1\]\[8\] sky130_fd_sc_hd__dfrtp_1
X_3743_ _0386_ _0385_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3674_ _0815_ _0816_ _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2625_ _1923_ _1941_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2556_ _1906_ _1909_ _1946_ _1904_ _1947_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__o311a_4
X_2487_ _1874_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__inv_2
X_4226_ _1392_ _1395_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4157_ _1315_ _1326_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__o21a_1
X_3108_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__inv_2
XFILLER_0_37_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4088_ _1243_ _1258_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__xnor2_2
X_3039_ _2292_ _2319_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput14 theta[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_2410_ net153 net154 VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__nor2_1
X_3390_ _0513_ _0519_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4011_ net87 _1179_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4775_ net266 _0188_ net173 VGND VGND VPWR VPWR slte0.opB\[7\] sky130_fd_sc_hd__dfrtp_1
X_3726_ _0901_ _0887_ _0910_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__o22a_1
XFILLER_0_15_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3657_ net142 _0786_ _0775_ net148 VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a211oi_1
X_2608_ _1991_ _1992_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__xnor2_1
X_3588_ net139 net142 VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2539_ _1929_ _1930_ net97 VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__a21oi_1
X_4209_ _1355_ _1379_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4623__37 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__inv_2
XFILLER_0_65_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_4
X_2890_ _1968_ _1974_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__nor2_2
X_4560_ _0950_ _1718_ _1721_ _0975_ net297 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a32o_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4491_ _1658_ _1660_ _1661_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__o21ai_2
X_3511_ net147 _0696_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21oi_1
X_3442_ _0619_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nand2_1
X_3373_ net137 _0558_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_75_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4758_ net249 _0171_ net179 VGND VGND VPWR VPWR vec\[0\]\[7\] sky130_fd_sc_hd__dfstp_1
X_3709_ _0893_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3991_ net81 _1158_ _1160_ _1161_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__o22ai_2
X_2942_ _2097_ _2244_ _2280_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2873_ _1970_ _2219_ _2220_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4543_ _0950_ _1708_ _1709_ _0975_ net313 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__a32o_1
XFILLER_0_4_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4474_ _1641_ _1643_ _1636_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3425_ _0604_ _0608_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__xnor2_1
X_3356_ _0541_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__and2_1
X_3287_ _0473_ _0465_ net138 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3210_ _0395_ _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2b_1
X_4190_ _1317_ _1323_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__xnor2_2
X_4659__73 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__inv_2
X_3141_ net118 _0326_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__a21oi_1
X_3072_ net105 net108 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nand2_2
X_3974_ _1106_ _1107_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2925_ net158 net166 _1830_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_17_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2856_ _1985_ _2208_ net167 net122 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_32_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2787_ _2121_ _2144_ _2145_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4526_ _0991_ _0995_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__mux2_4
X_4457_ _1616_ _1627_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__xnor2_1
X_3408_ _0591_ _0589_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4388_ _1557_ _1558_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__nor2_1
X_3339_ _0524_ _0521_ _0522_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nor3_1
XFILLER_0_36_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2710_ net101 net97 net95 net91 net165 net161 VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__mux4_1
X_3690_ _0872_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2641_ _1967_ net1 VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__and2_1
X_2572_ _1962_ _1963_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__xnor2_1
X_4311_ _1465_ _1481_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4242_ _1400_ _1411_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4173_ _1305_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__xnor2_2
X_3124_ _0300_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__xor2_1
X_3055_ slte0.opA\[0\] _2249_ _2308_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a21o_1
X_3957_ net68 net73 VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__xor2_4
XFILLER_0_9_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2908_ _2246_ _2249_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3888_ _1054_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2839_ _2111_ _2195_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4509_ _0990_ _1006_ net54 VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4629__43 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__inv_2
XFILLER_0_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4590__4 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_25_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3811_ _0258_ _0982_ _0984_ _0975_ net298 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__a32o_1
X_4791_ net282 _0204_ net173 VGND VGND VPWR VPWR vec\[1\]\[7\] sky130_fd_sc_hd__dfrtp_1
X_3742_ _0924_ _0928_ _0593_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3673_ _0814_ _0811_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__and2b_1
X_2624_ _1923_ _1941_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2555_ net74 _1900_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_34_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2486_ _1875_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__or2_1
X_4225_ _1391_ _1387_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__and2b_1
X_4156_ _1316_ _1325_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__or2_1
X_3107_ _2175_ _0288_ _0290_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__a2bb2oi_1
X_4087_ _1245_ _1256_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__o21a_1
X_3038_ _2292_ _2319_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput15 theta[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_70_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4010_ net343 _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_47_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4774_ net265 _0187_ net172 VGND VGND VPWR VPWR slte0.opB\[6\] sky130_fd_sc_hd__dfrtp_1
X_3725_ _0866_ _0900_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3656_ _0802_ _0786_ net148 VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__and3b_1
X_2607_ _1901_ _1947_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__or2b_1
X_3587_ net145 net148 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__nand2_1
X_2538_ _1762_ _1790_ _1856_ _1859_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__a31o_1
X_4208_ _1338_ _1377_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__xnor2_1
X_2469_ _1852_ _1860_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__or2_1
X_4139_ _1297_ _1309_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout170 state\[0\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_2
Xfanout181 net184 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_4
XFILLER_0_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3510_ net147 _0658_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nor2_1
X_4490_ _1147_ _1149_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__xor2_1
X_3441_ _0620_ _0626_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a21oi_2
X_3372_ net137 _0499_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4757_ net248 _0170_ net182 VGND VGND VPWR VPWR vec\[0\]\[6\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3708_ _0872_ _0876_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__a21oi_2
X_3639_ net139 net145 _0658_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3990_ net76 net82 VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__nand2_2
X_2941_ slte0.opA\[8\] _2282_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2872_ net170 net138 VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4542_ _1075_ _1080_ _1707_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__or3b_1
X_4473_ _1636_ _1641_ _1643_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__nor3_1
XFILLER_0_20_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3424_ net137 _0610_ net143 VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o21ai_1
X_3355_ net120 net121 VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__or2_1
X_3286_ _0463_ _0459_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_8_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ net119 _0301_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__nor2_1
X_3071_ _2233_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_8
X_4674__88 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__inv_2
XFILLER_0_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3973_ _1142_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2924_ slte0.opA\[13\] _2263_ _2265_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2855_ _2169_ _2174_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__xnor2_1
X_4525_ _1692_ _1694_ _1695_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2786_ net138 _2120_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__and2_1
X_4456_ _1617_ _1619_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3407_ _0581_ _0586_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__and2b_1
X_4387_ _1514_ _1530_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__xor2_1
X_3338_ _0521_ _0522_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__o21a_1
X_3269_ _0452_ _0453_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2640_ _1971_ _1932_ _2014_ _2015_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2571_ _1744_ _1794_ _1872_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4310_ _1467_ _1479_ _1480_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4241_ _1400_ _1411_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__xnor2_2
X_4172_ net88 net94 VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__nand2_4
X_3123_ net104 _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__nand2_1
X_3054_ slte0.opA\[0\] _2249_ _2308_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3956_ _1122_ _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__xor2_2
X_2907_ _1830_ _2241_ _2248_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__o21ai_4
X_3887_ net67 _1056_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2838_ _2113_ _2183_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2769_ _2067_ _2127_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__xnor2_1
X_4508_ net65 _1011_ _1015_ _1017_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__a22o_1
X_4439_ _1605_ _1607_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4644__58 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__inv_2
X_4790_ net281 _0203_ net173 VGND VGND VPWR VPWR vec\[1\]\[6\] sky130_fd_sc_hd__dfrtp_1
X_3810_ _0688_ _0735_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__or3_1
X_3741_ _0925_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3672_ _0845_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__xor2_1
X_2623_ _2002_ _1989_ _2003_ net85 _1971_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a32o_1
XFILLER_0_2_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2554_ _1915_ _1944_ _1945_ _1913_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__o211a_1
X_2485_ net60 _1876_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__and2_1
X_4224_ _1394_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__inv_2
X_4155_ _1316_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__xnor2_2
X_4686__100 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__inv_2
X_3106_ _0291_ _0292_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__nor2_1
X_4086_ _1246_ _1255_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__or2_1
X_3037_ _1971_ slte0.opA\[7\] _1985_ _0236_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3939_ _1069_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput16 theta[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4773_ net264 _0186_ net172 VGND VGND VPWR VPWR slte0.opB\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3724_ _0899_ _0897_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__and2b_1
X_3655_ _0502_ _0654_ _0840_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__and4_1
XFILLER_0_70_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2606_ _1906_ _1909_ _1946_ _1904_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_11_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3586_ _0771_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__nand2_1
X_2537_ _1762_ _1790_ _1856_ _1859_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__nand4_1
X_2468_ _1856_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4207_ _1338_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__nor2_1
X_2399_ _1762_ _1790_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__nand2_2
X_4138_ _1300_ _1304_ _1308_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__a21oi_1
X_4069_ _1224_ _1239_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__xor2_2
XFILLER_0_78_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_4
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_4
Xfanout182 net184 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_4
X_4614__28 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__inv_2
XFILLER_0_60_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3440_ _0625_ _0621_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__and2b_1
X_3371_ _0499_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_75_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4756_ net247 _0169_ net182 VGND VGND VPWR VPWR vec\[0\]\[5\] sky130_fd_sc_hd__dfstp_1
X_3707_ _0875_ _0873_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__and2b_1
X_3638_ net148 net151 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__or2_1
X_3569_ net121 net127 _0394_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and3_1
XFILLER_0_38_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold5 net35 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
X_2940_ _1793_ _2259_ _2281_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2871_ _2218_ _2144_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4541_ _1076_ _1707_ _1080_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_4_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4472_ _1266_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3423_ net132 net139 VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__xor2_4
XFILLER_0_40_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3354_ net120 net121 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand2_1
X_3285_ _0444_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__xor2_1
XFILLER_0_29_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4739_ net230 _0152_ net172 VGND VGND VPWR VPWR slte0.opA\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3070_ _0257_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
X_3972_ _1119_ _1138_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__xnor2_1
X_2923_ _1794_ _2264_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2854_ _1985_ _2206_ _2207_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2785_ _2126_ _2143_ _2124_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4524_ _0993_ _1009_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4455_ _1614_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__xnor2_1
X_3406_ _0587_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4386_ _1555_ _1556_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__nand2_1
X_3337_ _0523_ _0405_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__xnor2_1
X_3268_ _0390_ _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__xnor2_2
X_3199_ _0384_ _0380_ _0383_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__nor3_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2570_ net104 _1960_ _1961_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4240_ _1402_ _1409_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__a21oi_2
X_4171_ net82 net90 _1340_ _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__a31o_1
X_3122_ _0302_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_2
X_3053_ _1989_ _0246_ _0247_ net330 _1968_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__a32o_1
XFILLER_0_26_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3955_ _1123_ _1125_ net345 VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2906_ net156 _2247_ _2243_ net154 VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__o2bb2a_1
X_3886_ net67 _1025_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2837_ net167 net105 _1981_ _2194_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o22a_1
X_2768_ _1792_ _2083_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4507_ _1654_ _1670_ _1673_ _1677_ _1081_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__a2111o_1
X_2699_ _1827_ _2042_ _2057_ _1830_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4438_ net74 net342 net81 VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__o21ai_1
X_4369_ _1538_ _1539_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3740_ _0578_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__or2b_1
X_3671_ _0854_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2622_ _1919_ _1943_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2553_ net79 _1908_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2484_ _1799_ _1871_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__xor2_1
X_4223_ net94 _1393_ net100 VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__o21ai_1
X_4154_ _1317_ _1323_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__o21a_1
X_3105_ _2175_ _0288_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__xnor2_1
X_4085_ _1246_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__xnor2_1
X_3036_ _0233_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__xnor2_1
X_3938_ _1067_ _1068_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3869_ _1033_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput17 theta[8] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4772_ net263 _0185_ net172 VGND VGND VPWR VPWR slte0.opB\[4\] sky130_fd_sc_hd__dfrtp_1
X_3723_ _0903_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__xor2_1
XFILLER_0_70_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3654_ net127 net130 net139 _0554_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__and4b_1
X_2605_ _1988_ _1989_ _1990_ net295 _1971_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a32o_1
X_3585_ _0707_ _0731_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2536_ _1926_ _1927_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__nor2_1
X_2467_ _1822_ _1820_ _1858_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__o21a_1
X_4206_ _1357_ _1375_ _1376_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2398_ _1782_ _1785_ _1789_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4137_ _1306_ _1307_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4068_ _1226_ _1237_ _1238_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__o21ai_2
X_3019_ _2329_ _2272_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout183 net184 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_2
Xfanout172 net173 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout150 vec\[0\]\[1\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_2
Xfanout161 gm0.iter\[1\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3370_ net131 net137 VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__nand2_2
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4755_ net246 _0168_ net182 VGND VGND VPWR VPWR vec\[0\]\[4\] sky130_fd_sc_hd__dfstp_1
X_3706_ _0752_ _0758_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__xnor2_2
X_3637_ net148 net151 VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3568_ _0736_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2519_ _1888_ _1837_ _1910_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__a21oi_1
X_3499_ _0682_ _0684_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_58_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold6 net49 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2870_ _2145_ _2121_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4540_ _1706_ _1078_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__or2b_1
X_4471_ _1638_ _1640_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3422_ _0604_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nand2_1
X_3353_ _0283_ _0490_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3284_ _0457_ _0465_ _0469_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__o31a_1
XFILLER_0_75_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2999_ _2337_ _2336_ _2340_ _2239_ _2338_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__a2111o_1
X_4738_ net229 _0151_ net172 VGND VGND VPWR VPWR slte0.opA\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_39_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3971_ net81 _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__xor2_1
X_2922_ _1830_ _1797_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2853_ net168 net119 VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__nor2_1
X_2784_ _2129_ _2141_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_60_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4523_ _1693_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__inv_2
X_4454_ _1623_ _1624_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__nor2_1
X_3405_ _0589_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__xnor2_1
X_4385_ _1515_ _1528_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__xor2_1
X_3336_ _0400_ _0403_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__xnor2_1
X_3267_ _0362_ _0448_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__xnor2_2
X_3198_ _0380_ _0383_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__o21ai_1
X_4665__79 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__inv_2
XFILLER_0_48_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4170_ net87 _1339_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__nor2_1
X_3121_ net112 _0306_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__mux2_1
X_3052_ _2310_ _2313_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3954_ _1095_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__xnor2_4
X_3885_ _1055_ _1025_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_18_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2905_ _1841_ net158 net162 VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__and3_1
X_2836_ _2191_ _2193_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2767_ _2124_ _2125_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4506_ _1674_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__nand2_1
X_2698_ net85 net83 net79 net77 net165 net160 VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__mux4_1
X_4437_ _1605_ _1607_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__and2_1
X_4368_ _1457_ _1484_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__xor2_1
X_3319_ _0504_ _0502_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__and2b_1
X_4299_ _1349_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3670_ _0803_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a21oi_1
X_2621_ _1919_ _1943_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__nand2_1
X_2552_ _1919_ _1943_ _1917_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_10_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4222_ net92 net98 VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__xor2_2
X_2483_ net57 _1873_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__and2_1
X_4153_ _1318_ _1322_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__or2_1
X_3104_ _0266_ _0269_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__xnor2_1
X_4084_ _1247_ _1253_ _1254_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o21a_1
X_3035_ _2286_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__nand2_1
X_4635__49 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__inv_2
X_3937_ _1106_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__nand2_1
X_3868_ net72 _1024_ _1032_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__nor3_1
X_3799_ _0924_ _0926_ _0578_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2819_ net118 _2176_ _2172_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_21_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput18 theta[9] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4771_ net262 _0184_ net171 VGND VGND VPWR VPWR slte0.opB\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_55_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3722_ _0905_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3653_ _0786_ _0747_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__and2_1
X_2604_ _1901_ _1948_ _1898_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__o21ai_1
X_3584_ _0765_ _0769_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__a21oi_1
X_2535_ net91 _1925_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__nor2_1
X_2466_ _1838_ _1834_ _1857_ _1742_ _1841_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__o221a_1
X_4205_ _1374_ _1358_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__and2b_1
X_4136_ _1300_ _1304_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__xor2_1
X_2397_ slte0.opA\[16\] _1786_ _1788_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__or3b_2
X_4067_ _1227_ _1236_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__or2_1
X_3018_ _1971_ slte0.opA\[12\] _0221_ _0222_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_2
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
Xfanout173 net174 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_4
Xfanout151 vec\[0\]\[0\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_4
Xfanout184 net2 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_2
XFILLER_0_69_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4605__19 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__inv_2
XFILLER_0_75_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4754_ net245 _0167_ net182 VGND VGND VPWR VPWR vec\[0\]\[3\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_50_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3705_ _0888_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3636_ _0652_ _0793_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3567_ net129 net132 VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__or2_1
X_2518_ _1844_ _1862_ _1792_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__a21oi_1
X_3498_ _0614_ _0639_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2449_ net152 VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__inv_2
X_4119_ _1268_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__xnor2_2
Xclone3 net71 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_4
XFILLER_0_81_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold7 net27 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_57_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4470_ _1638_ _1640_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3421_ net141 _0606_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a21oi_1
X_3352_ _0492_ _0495_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3283_ _0451_ _0456_ _0446_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2998_ _2337_ _2262_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4737_ net228 _0150_ net172 VGND VGND VPWR VPWR slte0.opA\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_16_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3619_ _0804_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4593__7 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__inv_2
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3970_ _1127_ _1129_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_15_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2921_ _2256_ _2258_ _2260_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2852_ _2205_ _2177_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2783_ net144 _2128_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nand2_1
X_4522_ _1682_ _1689_ _1685_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4453_ _1615_ _1622_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__nor2_1
X_3404_ _0474_ _0535_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4384_ _1542_ _1553_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__o21ai_1
X_3335_ _0433_ _0443_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3266_ _0307_ _0450_ _0449_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__and3_1
X_3197_ _0334_ _0346_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_77_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3120_ net103 net106 net109 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__nand3_2
XFILLER_0_26_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3051_ _2310_ _2313_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand2_1
X_3953_ net67 net73 VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__nand2_4
X_3884_ net62 net67 VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nand2_2
X_2904_ _1839_ _2241_ _2245_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2835_ _2192_ _2107_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2766_ net140 _2123_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4505_ _1152_ _1675_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__and2_1
X_2697_ _1803_ _2055_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__nand2_1
X_4436_ net76 _1404_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__a21oi_1
X_4367_ _1533_ _1535_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__nor2_1
X_3318_ _0502_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4298_ _1389_ _1458_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__xnor2_2
X_3249_ net116 vec\[0\]\[10\] VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2620_ _1996_ _1989_ _2001_ net83 _1971_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a32o_1
XFILLER_0_12_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2551_ _1923_ _1941_ _1942_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__a21o_1
X_2482_ net57 _1873_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4221_ _1387_ _1391_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__xnor2_2
X_4152_ _1318_ _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__xnor2_2
X_3103_ _0273_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__and2_1
X_4083_ _1248_ _1252_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__or2_1
X_3034_ _2320_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__inv_2
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3936_ _1083_ _1100_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__xnor2_1
X_3867_ _1035_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__nor2_1
X_3798_ _0258_ _0971_ _0974_ _0975_ net301 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a32o_1
XFILLER_0_5_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4693__107 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__inv_2
X_2818_ _2175_ _2176_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2749_ _2041_ _2104_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__xnor2_1
X_4419_ _1577_ _1578_ _1589_ _1563_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4770_ net261 _0183_ net171 VGND VGND VPWR VPWR slte0.opB\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_55_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3721_ _0892_ _0906_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3652_ _0817_ _0820_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_70_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2603_ _1969_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__clkbuf_4
X_3583_ _0709_ _0727_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2534_ net91 _1925_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2465_ net150 net146 net144 net140 net164 net161 VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__mux4_1
X_4204_ _1358_ _1374_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__xnor2_2
X_2396_ _1787_ slte0.opA\[14\] _1749_ _1750_ _1752_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__o32a_1
X_4135_ net90 _1305_ net96 VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__o21ai_1
X_4066_ _1227_ _1236_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3017_ _1981_ _2332_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3919_ net65 net70 VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__nand2_2
XFILLER_0_6_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout130 vec\[0\]\[7\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
Xfanout163 net166 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_4
Xfanout174 net2 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__buf_4
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_4
Xfanout141 vec\[0\]\[4\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4753_ net244 _0166_ net182 VGND VGND VPWR VPWR vec\[0\]\[2\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3704_ vec\[0\]\[0\] _0747_ _0890_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3635_ net148 _2133_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__nor2_1
X_3566_ _0391_ _0718_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__xor2_2
X_2517_ net79 _1908_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__nor2_1
X_3497_ _0677_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__nor2_1
X_2448_ net140 net138 net132 net129 net164 net161 VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__mux4_2
X_2379_ _1766_ _1768_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__a21o_1
X_4118_ _1285_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__xnor2_2
X_4049_ _1216_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__xnor2_1
Xclone4 net72 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_4
XFILLER_0_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold8 net19 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_72_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3420_ net141 _0554_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nor2_1
X_3351_ _0498_ _0508_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3282_ net133 _0467_ _0464_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_48_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2997_ _2239_ _2262_ _2336_ _2337_ _2338_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__o311ai_1
X_4736_ net227 _0149_ net171 VGND VGND VPWR VPWR slte0.opA\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3618_ net136 net139 VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__or2_1
X_3549_ net130 net132 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2920_ _2259_ _2261_ slte0.opA\[14\] VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2851_ _2169_ _2174_ _2172_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2782_ _2136_ _2139_ _2140_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__a21o_1
X_4521_ _1157_ _1678_ _1687_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a211o_1
XFILLER_0_25_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4452_ _1615_ _1622_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__and2_1
X_3403_ _0533_ _0534_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4383_ _1543_ _1552_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__nand2_1
X_3334_ _0425_ _0432_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__nor2_1
X_3265_ _0307_ _0449_ _0450_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__a21oi_1
X_3196_ _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4719_ net210 _0132_ net183 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_12_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3050_ _1989_ _0244_ _0245_ net331 _2006_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__a32o_1
X_3952_ _1095_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__inv_2
X_4670__84 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__inv_2
X_3883_ net56 net61 _1000_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__and3_1
X_2903_ net152 net162 _2242_ _2244_ _2097_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__o311a_1
X_2834_ net107 _2106_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4504_ _1151_ _1146_ _1150_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__or3_1
X_2765_ net140 _2123_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2696_ _2054_ _2042_ net157 VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4435_ net76 _1128_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__nor2_1
X_4366_ _1532_ _1536_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__xnor2_1
X_3317_ net121 net128 _0493_ _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__a31o_1
X_4297_ _1440_ _1446_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__xnor2_4
X_3248_ net125 _0434_ net131 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__o21ai_1
X_3179_ net116 net122 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2550_ net89 _1921_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2481_ _1744_ _1872_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__xor2_1
X_4220_ net99 _1352_ _1388_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__a31o_1
X_4151_ _1091_ _1320_ _1321_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__a21oi_2
X_3102_ _0271_ _0272_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__nand2_1
X_4082_ _1248_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__xnor2_2
X_3033_ _2292_ _2319_ _2290_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3935_ _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__and2_1
X_3866_ _1004_ _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__nand2_1
X_3797_ _0945_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__clkbuf_8
X_2817_ _2050_ _2101_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2748_ net107 _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4418_ _1432_ _1567_ _1580_ _1588_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__a31o_1
X_2679_ net153 net341 _2037_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__or3_1
X_4349_ _1507_ _1519_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4640__54 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__inv_2
X_3720_ _0893_ _0895_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3651_ _0821_ _0830_ _0831_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__o211a_1
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2602_ _1898_ _1901_ _1948_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__or3_1
X_3582_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nand2_1
X_2533_ _1849_ _1924_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2464_ net104 _1853_ _1855_ _1841_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__a22o_4
X_4203_ _1360_ _1372_ _1373_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2395_ slte0.opB\[14\] VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__inv_2
X_4134_ net86 net92 VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__xor2_4
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4065_ _1228_ _1234_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3016_ _2331_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3918_ _1027_ _1086_ _1085_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_46_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3849_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__inv_2
Xfanout131 vec\[0\]\[7\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_4
Xfanout120 vec\[0\]\[11\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_4
Xfanout153 gm0.iter\[4\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_2
Xfanout142 vec\[0\]\[3\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_4
Xfanout164 net165 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_6
Xfanout175 net176 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_4
XFILLER_0_56_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_0_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4752_ net243 _0165_ net182 VGND VGND VPWR VPWR vec\[0\]\[1\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_28_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3703_ _2133_ _0840_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__or3_1
X_3634_ _0791_ _0797_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3565_ _0651_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__xnor2_2
X_3496_ _0645_ _0681_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2516_ _1907_ _1867_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2447_ _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2378_ slte0.opB\[7\] _1769_ _1767_ slte0.opB\[6\] VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__a22o_1
X_4117_ _1202_ _1286_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__a21oi_2
X_4048_ _1001_ _1218_ _1054_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__a21oi_1
Xclone5 vec\[1\]\[4\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_2
XFILLER_0_38_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_18_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold9 net28 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4610__24 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__inv_2
XFILLER_0_25_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3350_ _0518_ _0520_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3281_ net126 net133 _0458_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4735_ net226 _0148_ net171 VGND VGND VPWR VPWR slte0.opA\[1\] sky130_fd_sc_hd__dfrtp_1
X_2996_ slte0.opA\[16\] _2238_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3617_ net136 net139 VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__nand2_1
X_3548_ _0730_ _0732_ _0689_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__o21a_1
X_3479_ _0648_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__and2_1
X_4676__90 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__inv_2
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2850_ net167 net115 _1981_ _2204_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__o22a_1
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2781_ _2138_ net146 VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__and2b_1
X_4520_ _1689_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4451_ _1616_ _1620_ _1621_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__o21ai_1
X_3402_ _0585_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4382_ _1543_ _1552_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__nor2_1
X_3333_ _0513_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ _0307_ _0449_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__a21o_1
X_3195_ _0353_ _0379_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__xor2_2
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2979_ _2292_ _2319_ _2320_ _2290_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__a211o_1
X_4718_ net209 _0131_ net183 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3951_ net62 net67 _1120_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__a31o_1
XFILLER_0_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2902_ _1839_ _2243_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__or2_1
X_3882_ net64 _1052_ net72 VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__o21ai_1
X_2833_ _2111_ _2113_ _2183_ _2109_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__o31a_1
X_2764_ _2086_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__xnor2_1
X_4503_ _1153_ _1117_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2695_ net74 net71 net68 net66 net165 net160 VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4434_ net65 net294 _1277_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__a31o_1
X_4365_ _1533_ _1535_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__xor2_2
X_3316_ net124 _0488_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4296_ _1464_ _1466_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__or2_4
X_3247_ net121 net127 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__xor2_4
X_4646__60 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__inv_2
X_3178_ _0330_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__inv_2
XFILLER_0_32_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2480_ _1794_ _1799_ _1871_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4150_ net65 net294 _1052_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__and3_1
X_3101_ _0285_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__or2_1
X_4081_ _1056_ _1250_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__a21oi_2
X_3032_ _0231_ _0232_ net336 _1978_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3934_ net76 _1102_ _1103_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__or3_1
X_3865_ _0998_ _1003_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2816_ net119 VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__inv_2
X_3796_ _0592_ _0580_ _0970_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__or3b_1
XFILLER_0_5_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2747_ _2038_ _2105_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2678_ _2035_ net162 _2036_ net158 VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__a211o_1
XFILLER_0_78_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4417_ _1564_ _1574_ _1587_ _1562_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4348_ net91 net94 VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__nor2_1
X_4279_ _1448_ _1438_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__or2_4
XFILLER_0_49_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3650_ _0824_ _0821_ _0830_ _0835_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__a311o_1
Xrebuffer1 _1095_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_6
X_2601_ _1978_ net68 _1985_ _1987_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a22o_1
X_3581_ _0764_ _0763_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__xnor2_1
X_2532_ _1762_ _1790_ _1861_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__and3_1
X_4202_ _1361_ _1371_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__or2_1
X_2463_ _1806_ _1824_ _1840_ _1854_ _1807_ _1822_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__mux4_1
X_2394_ slte0.opA\[15\] slte0.opB\[15\] VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4133_ net93 _1302_ _1303_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a21oi_2
X_4064_ _1229_ _1233_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__or2_1
X_3015_ _2272_ _2276_ _2328_ _2329_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a31o_1
X_4616__30 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__inv_2
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3917_ _1027_ _1085_ _1086_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__o31a_1
XFILLER_0_46_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3848_ _0996_ _1004_ _1014_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__o22a_1
X_3779_ _0961_ _0959_ _0956_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__a21bo_1
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_8
Xfanout110 vec\[0\]\[14\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_4
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_8
Xfanout154 gm0.iter\[3\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
Xfanout143 net144 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_2
Xfanout132 net135 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_4
Xfanout176 net2 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4751_ net242 _0164_ net182 VGND VGND VPWR VPWR vec\[0\]\[0\] sky130_fd_sc_hd__dfstp_1
X_3702_ _0786_ _0747_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nor2_1
X_3633_ _0774_ _0818_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3564_ net140 _0736_ _0737_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__o21a_1
X_3495_ _0645_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__nor2_1
X_2515_ _1793_ _1863_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2446_ net154 net157 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__or2b_1
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4116_ _1214_ _1222_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__and2_1
X_2377_ slte0.opA\[7\] VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__inv_2
X_4047_ _1192_ _1217_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__and2_1
Xclone6 net74 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_81_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3280_ _0466_ _0458_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_29_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4734_ net225 _0147_ net171 VGND VGND VPWR VPWR slte0.opA\[0\] sky130_fd_sc_hd__dfrtp_2
X_2995_ slte0.opA\[15\] _2237_ _2238_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__or3_1
XFILLER_0_43_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3616_ _0786_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__xnor2_1
X_3547_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__inv_2
X_3478_ net124 net128 VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__or2_1
X_2429_ _1803_ _1820_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2780_ net146 _2138_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__xnor2_1
X_4450_ _1619_ _1617_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__or2b_1
X_3401_ _0530_ _0584_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__and2_1
X_4381_ _1544_ _1550_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__a21bo_1
X_3332_ _0479_ _0517_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4689__103 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_37_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3263_ net103 _0426_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__xnor2_1
X_3194_ vec\[0\]\[8\] _0376_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__nand2_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_72_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2978_ slte0.opA\[7\] _2285_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4717_ net208 _0130_ net183 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_44_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1 _0951_ VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4579_ _1421_ _1599_ _1723_ _2014_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_55_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_73_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3950_ net64 _0990_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__nor2_1
X_2901_ _1841_ _1797_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__nand2_1
X_3881_ net62 net69 VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__xor2_4
X_2832_ _1978_ net102 _2189_ _2190_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__a22o_1
X_2763_ _1792_ _2084_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4502_ _1662_ _1667_ _1672_ _1668_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2694_ _1803_ _2052_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4433_ net67 _0992_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4364_ _1494_ _1512_ _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_67_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4295_ _1463_ _1460_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__and2b_1
X_3315_ net133 _0467_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21o_1
X_3246_ _0425_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__xnor2_1
X_3177_ _0303_ _0356_ _0357_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4661__75 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__inv_2
XFILLER_0_76_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3100_ net108 _0286_ net115 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__o21ai_1
X_4080_ net63 net67 _1025_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3031_ _2286_ _2321_ _0230_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_53_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3933_ _1102_ _1103_ net76 VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_73_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3864_ net54 _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nand2_1
X_2815_ _2172_ _2173_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__nor2_1
X_3795_ net318 _0947_ _0973_ net340 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2746_ _1794_ _2041_ _2104_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__o21a_1
X_2677_ net57 net162 VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4416_ _1564_ _1574_ _1586_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4347_ _1181_ _1501_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__xor2_2
X_4278_ _1438_ _1448_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__xnor2_4
X_3229_ _0399_ _0414_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and2b_1
XFILLER_0_68_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2600_ _1949_ _1986_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__xnor2_1
Xrebuffer2 _1479_ VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_1
X_3580_ _0739_ _0744_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__a21o_1
X_2531_ _1922_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4201_ _1361_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__xnor2_2
X_2462_ net151 net150 net146 net144 net164 net161 VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__mux4_1
X_2393_ _1754_ _1783_ _1784_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__and3_1
X_4132_ net93 _1168_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nor2_1
X_4063_ _1229_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__xnor2_1
X_3014_ _1978_ slte0.opA\[13\] _0218_ _0219_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3916_ _1084_ _1027_ _2035_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a21oi_1
X_4631__45 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__inv_2
XFILLER_0_6_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3847_ _1015_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__xnor2_1
X_3778_ _0348_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2729_ _1828_ _2051_ _2080_ _1830_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__a22o_1
Xfanout100 net101 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_4
Xfanout122 vec\[0\]\[10\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_4
Xfanout111 net114 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_4
Xfanout155 gm0.iter\[3\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_2
Xfanout144 vec\[0\]\[3\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_2
Xfanout133 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_2
Xfanout166 gm0.iter\[0\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
Xfanout177 net179 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4750_ net241 _0163_ net180 VGND VGND VPWR VPWR slte0.opA\[16\] sky130_fd_sc_hd__dfrtp_1
X_3701_ net141 net146 _0870_ _0869_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3632_ _0790_ _0799_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3563_ _0715_ _0721_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__xnor2_2
X_2514_ _1904_ _1905_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__nand2_1
X_3494_ _0675_ _0679_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__a21oi_1
X_2445_ net153 _1836_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4115_ _1214_ _1222_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__or2_1
X_2376_ slte0.opB\[6\] _1767_ _1764_ slte0.opB\[5\] VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__o22a_1
X_4046_ net65 net67 VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4601__15 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__inv_2
X_2994_ _2266_ _2269_ _2332_ _2333_ _2335_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__o311a_1
XFILLER_0_71_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4733_ net224 _0146_ net179 VGND VGND VPWR VPWR gm0.iter\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3615_ _0747_ _0775_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__xnor2_1
X_3546_ _0689_ _0730_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nor3_1
X_3477_ _0326_ _0623_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__xor2_2
X_2428_ _1800_ _1819_ _1807_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__mux2_1
X_2359_ slte0.opB\[12\] VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__inv_2
X_4029_ _1191_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4667__81 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__inv_2
XFILLER_0_72_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3400_ _0581_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__xnor2_1
X_4380_ _1545_ _1549_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__nand2_1
X_3331_ _0479_ _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3262_ _0261_ _0262_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__a211o_1
X_3193_ _0353_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__and2b_1
XFILLER_0_56_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2977_ _2297_ _2318_ _2295_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4716_ net207 _0129_ net183 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_8_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2 _1743_ VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkbuf_4
X_4578_ _1421_ _1723_ _1599_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__a21oi_1
X_3529_ _0367_ _0666_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_50_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2900_ net154 net156 VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__nand2_1
X_3880_ _1042_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2831_ _2107_ _2185_ _2188_ _1969_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__o31a_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2762_ net138 _2120_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__or2_1
X_4501_ _1667_ _1671_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4432_ _1601_ _1602_ net87 VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_41_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2693_ _2051_ _2040_ net156 VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4363_ _1495_ _1511_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4294_ _1437_ _1449_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__xor2_2
X_3314_ net133 _0458_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__nor2_1
X_3245_ _0427_ _0430_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__a21oi_1
X_3176_ net118 _0362_ net123 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_16_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4637__51 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__inv_2
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3030_ _0230_ _2286_ _2321_ _1975_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__a31o_1
X_3932_ _1096_ _1094_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__and2b_1
X_3863_ _1026_ _1031_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__xnor2_1
X_2814_ _2170_ _2171_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__and2_1
X_3794_ _0587_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2745_ _1794_ _2043_ _2103_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__o21ba_1
X_2676_ net54 VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4415_ _1583_ _1584_ _1585_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__or3b_1
X_4346_ _1498_ _1516_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__xnor2_1
X_4277_ _1440_ _1446_ _1447_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__a21oi_4
X_3228_ _0399_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__xor2_1
X_3159_ _0344_ _0345_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 _1175_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd1_1
X_2530_ net89 _1921_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2461_ net152 _1830_ _1804_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__and3_4
X_4200_ _1363_ _1369_ _1370_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21oi_2
X_2392_ _1759_ _1760_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__nor2_1
X_4131_ _1168_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__xnor2_4
X_4062_ _1028_ _1231_ _1232_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3013_ _2269_ _2332_ _0217_ _1969_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__o31a_1
XFILLER_0_78_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3915_ _1022_ _0997_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3846_ net53 _1008_ _1016_ net57 VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3777_ _0348_ _0956_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__or3b_1
X_2728_ _2060_ _2084_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__nand3b_1
X_2659_ _2026_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
Xfanout101 vec\[1\]\[0\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_2
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_4
X_4329_ net88 net91 VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__or2_1
Xfanout145 net146 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_2
Xfanout156 gm0.iter\[2\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_4
Xfanout123 net125 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_4
Xfanout134 net135 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_2
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_2
Xfanout178 net179 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_2
X_4607__21 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__inv_2
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3700_ _0843_ _0883_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3631_ _0790_ _0799_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3562_ _0745_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2513_ net77 _1903_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3493_ _0674_ _0647_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and2b_1
X_2444_ _1819_ _1828_ _1835_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__a21oi_1
X_2375_ slte0.opA\[6\] VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__inv_2
X_4114_ _1275_ _1284_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__xnor2_2
X_4045_ _1009_ _1203_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3829_ net54 net58 VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__xor2_4
XFILLER_0_34_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4598__12 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__inv_2
X_2993_ _2262_ _2334_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4732_ net223 _0145_ net179 VGND VGND VPWR VPWR gm0.iter\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_56_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3614_ _0774_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__xnor2_1
X_3545_ _0707_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__nor2_1
X_3476_ _0557_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__xnor2_1
X_2427_ net123 net122 net118 net116 net164 net160 VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__mux4_1
X_2358_ _1746_ slte0.opA\[13\] _1747_ _1748_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a2111o_1
X_4028_ _1195_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4682__96 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__inv_2
XFILLER_0_65_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3330_ _0511_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3261_ net112 net116 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__and2_2
X_3192_ _0373_ _0377_ _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_48_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2976_ _2302_ _2317_ _2300_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4715_ net206 _0128_ net182 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4577_ net321 _0946_ _1734_ _0258_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a22o_1
X_3528_ _0605_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__xnor2_2
X_3459_ _0619_ _0628_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2830_ _2107_ _2185_ _2188_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__o21ai_1
X_2761_ _2060_ _2119_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__xnor2_1
X_4500_ _1663_ _1664_ _1665_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__or3_1
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2692_ net71 net68 net66 net63 net163 net159 VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__mux4_2
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_1 _0951_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4431_ _1274_ _1273_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4362_ _1464_ _1482_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__xnor2_2
X_4293_ _1463_ _1460_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__and2b_1
X_3313_ net131 _0499_ net136 VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_67_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3244_ net103 _0259_ _0268_ _0426_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__and4_1
XFILLER_0_67_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3175_ net116 net121 VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__xor2_4
XFILLER_0_76_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2959_ slte0.opA\[4\] _2299_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4652__66 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__inv_2
X_3931_ _1089_ _1093_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__and2_1
X_3862_ _1024_ _1032_ net72 VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__o21a_1
XFILLER_0_73_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2813_ _2170_ _2171_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__nor2_1
X_3793_ _0595_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2744_ _1803_ _1888_ _2046_ _2102_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__a31o_1
X_2675_ _2034_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4414_ net97 _1566_ _1571_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4345_ _1499_ _1503_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__xnor2_1
X_4276_ _1445_ _1441_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__and2b_1
X_3227_ _0411_ _0413_ _0409_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a21o_1
X_3158_ _0343_ _0342_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__or2b_1
X_3089_ net111 _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer4 _1179_ VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_11_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2460_ _1841_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__and2_1
X_4130_ net87 net93 VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__nand2_2
X_2391_ slte0.opB\[11\] _1745_ _1758_ slte0.opB\[8\] _1757_ VGND VGND VPWR VPWR _1783_
+ sky130_fd_sc_hd__o221a_1
XPHY_EDGE_ROW_79_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4061_ net58 net64 _0997_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__and3_1
X_3012_ _2269_ _2332_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__o21ai_1
X_3914_ _1084_ _1022_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3845_ net54 net59 VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nor2_1
X_3776_ _0958_ _0421_ _0350_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2727_ _1822_ _2046_ _2085_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2658_ slte0.opB\[8\] net17 _2018_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__mux2_1
Xfanout113 net114 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2589_ _1976_ _1977_ net60 _1978_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__a2bb2o_1
Xfanout102 vec\[0\]\[16\] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_4
X_4328_ _1196_ _1473_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__xor2_2
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_2
Xfanout124 net125 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_8
Xfanout135 vec\[0\]\[6\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_4
X_4259_ net92 _1428_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__nor2_1
Xfanout157 gm0.iter\[2\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_2
Xfanout168 net170 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__buf_4
Xfanout179 net184 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_2
XFILLER_0_69_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4622__36 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__inv_2
XFILLER_0_64_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3630_ _0815_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3561_ net145 _0747_ net151 VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2512_ net77 _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3492_ _0677_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__and2_1
X_2443_ _1800_ _1827_ _1834_ _1830_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__a22o_1
X_2374_ slte0.opB\[5\] _1764_ _1765_ slte0.opB\[4\] VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4113_ _1282_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__or2b_1
XFILLER_0_75_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4044_ _1194_ _1193_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_74_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3828_ net56 net61 VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nand2_2
XFILLER_0_61_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3759_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4800_ net291 _0213_ net172 VGND VGND VPWR VPWR vec\[1\]\[16\] sky130_fd_sc_hd__dfrtp_1
X_2992_ slte0.opA\[14\] _2259_ _2261_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__nor3_1
X_4731_ net222 _0144_ net177 VGND VGND VPWR VPWR gm0.iter\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3613_ _0790_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3544_ _0690_ _0729_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__xnor2_1
X_3475_ net133 _0648_ _0649_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__o21ba_1
X_2426_ _1808_ _1798_ _1817_ _1803_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__o211a_1
X_2357_ slte0.opB\[15\] slte0.opA\[15\] VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__xor2_1
X_4027_ net82 _1196_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_39_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3260_ net112 net117 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nor2_1
X_3191_ _0355_ _0372_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__or2b_1
XFILLER_0_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4658__72 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__inv_2
XFILLER_0_72_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4714_ net205 _0127_ net182 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_1
X_2975_ _2305_ _2315_ _2316_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4576_ _1730_ _1733_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__nor2_1
X_3527_ net137 _0691_ _0692_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__o21a_1
X_3458_ _0634_ _0636_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__xnor2_1
X_3389_ _0568_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nor2_1
X_2409_ _1795_ _1800_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_24_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2760_ _2084_ _2086_ _1792_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_26_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2691_ _1811_ _2049_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__nor2_1
X_4430_ _1269_ _1272_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__and2_1
XANTENNA_2 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4361_ _1513_ _1531_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4292_ _1461_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__and2_1
X_3312_ net126 net135 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__xor2_4
XPHY_EDGE_ROW_60_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3243_ _0366_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__xnor2_1
X_3174_ _0283_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__xor2_1
XFILLER_0_76_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2958_ slte0.opA\[4\] _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2889_ net169 _2230_ _2231_ _2232_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__a31o_1
X_4559_ _1654_ _1655_ _1672_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__nand3_1
XFILLER_0_67_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput50 net50 VGND VGND VPWR VPWR sin[7] sky130_fd_sc_hd__clkbuf_4
X_4628__42 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__inv_2
XFILLER_0_53_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3930_ _1083_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__or2b_1
XFILLER_0_73_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3861_ _1026_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3792_ _0969_ _0970_ _0592_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__a21bo_1
X_2812_ _2053_ _2100_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2743_ _1888_ _2050_ _2101_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2674_ slte0.opB\[0\] net3 _2017_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__mux2_1
X_4413_ net98 _1566_ _1571_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4344_ net100 _1507_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__or2_1
X_4275_ _1441_ _1445_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__xnor2_4
X_3226_ _0398_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__and2_1
X_3157_ _0342_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__or2b_1
X_3088_ net102 _0259_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2390_ _1763_ _1771_ _1779_ _1781_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__a22o_1
X_4060_ _1174_ _1230_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__and2_1
X_3011_ _0216_ _2266_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3913_ net61 VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__inv_2
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3844_ _1984_ _1011_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3775_ _0957_ _0930_ _0931_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__nand3_1
X_2726_ _1839_ _2068_ _2070_ _1743_ _1842_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__o221a_1
XFILLER_0_54_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2657_ _2025_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
X_2588_ _1968_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__clkbuf_4
Xfanout103 net104 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_4
X_4327_ _1493_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__or2_1
Xfanout147 vec\[0\]\[2\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_2
Xfanout136 vec\[0\]\[5\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_8
Xfanout125 vec\[0\]\[9\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_2
Xfanout114 vec\[0\]\[13\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_2
X_4258_ _1305_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__or2b_1
Xfanout169 net170 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_4
Xfanout158 gm0.iter\[1\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_2
X_3209_ _0388_ _0392_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__xor2_1
X_4189_ _1354_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__or2_4
XFILLER_0_77_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ _0741_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__nor2_2
X_2511_ _1826_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__xnor2_1
X_3491_ net149 _0655_ _0676_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__or3_1
X_2442_ net138 net132 net129 net126 net166 net161 VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux4_1
XFILLER_0_75_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2373_ slte0.opA\[4\] VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__inv_2
X_4112_ _1281_ _1276_ _1212_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__nand3_1
X_4043_ _1212_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__and2_4
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3827_ net58 _0997_ net64 VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3758_ _2233_ _2017_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__nor2_2
X_2709_ net77 net75 net72 net68 net163 net159 VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3689_ _0873_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2991_ _2263_ _2265_ slte0.opA\[13\] VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__a21o_1
X_4730_ net221 _0143_ net177 VGND VGND VPWR VPWR gm0.iter\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_71_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3612_ _0791_ _0797_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__a21bo_1
X_3543_ _0690_ _0729_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3474_ _0620_ _0626_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__xnor2_2
X_2425_ net157 _1816_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__or2_1
X_2356_ slte0.opB\[14\] slte0.opA\[14\] VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__and2b_1
X_4026_ net84 _1159_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_38_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3190_ net128 _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4673__87 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__inv_2
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2974_ slte0.opA\[3\] _2304_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__nand2_1
X_4713_ net204 _0126_ net182 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
X_4575_ _1729_ _1724_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3526_ _0663_ _0669_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3457_ _0642_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__and2b_1
X_3388_ _0573_ _0572_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__xor2_1
X_2408_ net113 net110 net107 net104 net163 net159 VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__mux4_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4009_ net81 net87 VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__nand2_4
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2690_ _2037_ _2048_ _1807_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_3 net341 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ _1514_ _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__and2b_1
X_3311_ _0485_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4291_ net94 net101 VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__or2_1
X_3242_ _0330_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__xnor2_1
X_3173_ _0356_ _0358_ _0359_ net104 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__o211a_1
XFILLER_0_17_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2957_ _2259_ _2298_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2888_ net169 net150 _1975_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4558_ net311 _0946_ _1720_ net340 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a22o_1
X_4489_ _1612_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__nor2_1
X_3509_ _0658_ _0695_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput51 net51 VGND VGND VPWR VPWR sin[8] sky130_fd_sc_hd__clkbuf_4
Xoutput40 net40 VGND VGND VPWR VPWR sin[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4643__57 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__inv_2
X_3860_ _1023_ _1030_ _1024_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__a21oi_1
X_3791_ _0924_ _0928_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nand2_1
X_2811_ net121 VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__inv_2
XFILLER_0_66_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2742_ _1793_ _2053_ _2100_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2673_ _2033_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_4412_ _1344_ _1564_ _1568_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__a311o_1
XFILLER_0_41_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4343_ _1509_ _1510_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__xnor2_1
X_4274_ _1270_ _1443_ _1444_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__a21oi_4
X_3225_ net131 _0393_ _0397_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or3_1
X_3156_ _0311_ _0314_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__xor2_1
X_3087_ net105 net108 net102 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__or3b_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3989_ _1159_ _1158_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3010_ _2333_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__inv_2
XFILLER_0_64_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3912_ _1061_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3843_ _1005_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3774_ _0599_ _0929_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2725_ _2067_ _2083_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__and2b_1
X_2656_ slte0.opB\[9\] net18 _2018_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__mux2_1
X_2587_ _1958_ _1883_ _1956_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__and3_1
Xfanout104 vec\[0\]\[16\] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_4
X_4326_ _1491_ _1492_ _1461_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__o21a_1
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_2
Xfanout126 net128 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_4
Xfanout115 net117 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_4
X_4257_ net83 net85 VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__nand2_1
Xfanout148 net150 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
Xfanout159 gm0.iter\[1\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_2
X_3208_ vec\[0\]\[10\] _0394_ vec\[0\]\[8\] VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__o21ai_1
X_4188_ _1348_ _1353_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__nor2_1
X_3139_ _0301_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4613__27 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__inv_2
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2510_ _1888_ _1868_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3490_ _0655_ _0676_ net149 VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__o21ai_2
X_2441_ net153 _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2372_ slte0.opA\[5\] VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__inv_2
X_4111_ _1276_ _1212_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__a21oi_1
X_4042_ _1207_ _1211_ _1210_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_78_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3826_ net56 net61 VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__xor2_4
X_3757_ _0264_ _0939_ _0941_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_6_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2708_ _1839_ _2061_ _2062_ _1842_ _2066_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__o2111a_1
X_3688_ _0462_ _0850_ _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a21oi_2
X_2639_ net169 _1856_ net101 VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4309_ _1468_ _1478_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__or2_4
X_4679__93 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__inv_2
XFILLER_0_4_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2990_ _2272_ _2276_ _2328_ _2329_ _2331_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__a311oi_4
XFILLER_0_56_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3611_ _0792_ _0796_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nand2_1
X_3542_ _0709_ _0727_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__a21oi_1
X_3473_ _0657_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__xnor2_1
X_2424_ net122 net118 net116 net113 net164 net160 VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__mux4_1
X_2355_ slte0.opA\[14\] slte0.opB\[14\] VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__and2b_1
X_4025_ _1159_ _1161_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3809_ _0773_ _0921_ _0733_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__a21oi_1
X_4789_ net280 _0202_ net175 VGND VGND VPWR VPWR vec\[1\]\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2973_ _2310_ _2313_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__a21o_1
X_4712_ net203 _0125_ net174 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
X_4574_ _0950_ _1731_ _1732_ _0945_ net305 VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a32o_1
X_3525_ _0705_ _0703_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__xor2_1
X_3456_ _0600_ _0641_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nand2_1
X_3387_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2407_ _1795_ _1798_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__nand2_1
X_4649__63 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__inv_2
X_4008_ net77 net84 VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__xor2_4
XFILLER_0_79_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold40 slte0.opA\[3\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3310_ _0492_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_21_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4290_ net94 net101 VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3241_ net108 net111 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2_2
X_3172_ net109 net117 net113 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2956_ net154 _1739_ net162 _2242_ _1842_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2887_ _2132_ _2134_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4557_ _1717_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__xor2_1
XFILLER_0_40_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4488_ _1656_ _1657_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__xor2_1
X_3508_ net141 net145 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand2_2
X_3439_ _0621_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput30 net30 VGND VGND VPWR VPWR cos[5] sky130_fd_sc_hd__clkbuf_4
Xoutput41 net41 VGND VGND VPWR VPWR sin[13] sky130_fd_sc_hd__clkbuf_4
Xoutput52 net52 VGND VGND VPWR VPWR sin[9] sky130_fd_sc_hd__clkbuf_4
X_3790_ _0580_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__inv_2
XFILLER_0_73_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2810_ _2158_ _2163_ _2167_ _2168_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__a31o_1
X_2741_ _1793_ _2056_ _2099_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__o21a_1
XFILLER_0_81_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2672_ slte0.opB\[1\] net10 _2017_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__mux2_1
X_4589__3 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__inv_2
X_4411_ _1566_ _1388_ _1352_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4342_ _1494_ _1512_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__xor2_2
X_4273_ net74 net80 _1175_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__and3_1
X_3224_ _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nor2_1
.ends
